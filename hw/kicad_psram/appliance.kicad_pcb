# Repository rustydc/asic (continued)

## KiCad design hw/kicad/appliance.kicad_pcb (continued)

Schematic: memory.kicad_sch

Parts:
U_D0, U_D1, U_D2, U_D3: DDR4 x16; FBGA96_8x12_P0.8
U_M0a, U_M0b, U_M1a, U_M1b, U_M2a, U_M2b, U_M3a, U_M3b, U_M4a, U_M4b, U_M5a, U_M5b, U_M6a, U_M6b, U_M7a, U_M7b: LPDDR5X x32; FBGA315_15x21_P0.8

Connections (part):
A0_CH0_CA0: U_M0a.W15; also elsewhere on the board
A0_CH0_CA1: U_M0a.V1; also elsewhere on the board
A0_CH0_CA2: U_M0a.V2; also elsewhere on the board
A0_CH0_CA3: U_M0a.V3; also elsewhere on the board
A0_CH0_CA4: U_M0a.V4; also elsewhere on the board
A0_CH0_CA5: U_M0a.V5; also elsewhere on the board
A0_CH0_CA6: U_M0a.V6; also elsewhere on the board
A0_CH0_CA7: U_M0a.V7; also elsewhere on the board
A0_CH0_CA8: U_M0a.V8; also elsewhere on the board
A0_CH0_CA9: U_M0a.V9; also elsewhere on the board
A0_CH0_CA10: U_M0a.V10; also elsewhere on the board
A0_CH0_CA11: U_M0a.V11; also elsewhere on the board
A0_CH0_CA12: U_M0a.V12; also elsewhere on the board
A0_CH0_CA13: U_M0a.V13; also elsewhere on the board
A0_CH0_CK0_N: U_M0a.U2; also elsewhere on the board
A0_CH0_CK0_P: U_M0a.U1; also elsewhere on the board
A0_CH0_CK1_N: U_M0a.U4; also elsewhere on the board
A0_CH0_CK1_P: U_M0a.U3; also elsewhere on the board
A0_CH0_CS0: U_M0a.V14; also elsewhere on the board
A0_CH0_CS1: U_M0a.V15; also elsewhere on the board
A0_CH0_DMI0: U_M0a.W11; also elsewhere on the board
A0_CH0_DMI1: U_M0a.W12; also elsewhere on the board
A0_CH0_DMI2: U_M0a.W13; also elsewhere on the board
A0_CH0_DMI3: U_M0a.W14; also elsewhere on the board
A0_CH0_DQ0: U_M0a.AA1; also elsewhere on the board
A0_CH0_DQ1: U_M0a.AA2; also elsewhere on the board
A0_CH0_DQ2: U_M0a.AA3; also elsewhere on the board
A0_CH0_DQ3: U_M0a.AA4; also elsewhere on the board
A0_CH0_DQ4: U_M0a.AA5; also elsewhere on the board
A0_CH0_DQ5: U_M0a.AA6; also elsewhere on the board
A0_CH0_DQ6: U_M0a.AA7; also elsewhere on the board
A0_CH0_DQ7: U_M0a.AA8; also elsewhere on the board
A0_CH0_DQ8: U_M0a.AA9; also elsewhere on the board
A0_CH0_DQ9: U_M0a.AA10; also elsewhere on the board
A0_CH0_DQ10: U_M0a.AA11; also elsewhere on the board
A0_CH0_DQ11: U_M0a.AA12; also elsewhere on the board
A0_CH0_DQ12: U_M0a.AA13; also elsewhere on the board
A0_CH0_DQ13: U_M0a.AA14; also elsewhere on the board
A0_CH0_DQ14: U_M0a.AA15; also elsewhere on the board
A0_CH0_DQ15: U_M0a.Y1; also elsewhere on the board
A0_CH0_DQ16: U_M0a.Y2; also elsewhere on the board
A0_CH0_DQ17: U_M0a.Y3; also elsewhere on the board
A0_CH0_DQ18: U_M0a.Y4; also elsewhere on the board
A0_CH0_DQ19: U_M0a.Y5; also elsewhere on the board
A0_CH0_DQ20: U_M0a.Y6; also elsewhere on the board
A0_CH0_DQ21: U_M0a.Y7; also elsewhere on the board
A0_CH0_DQ22: U_M0a.Y8; also elsewhere on the board
A0_CH0_DQ23: U_M0a.Y9; also elsewhere on the board
A0_CH0_DQ24: U_M0a.Y10; also elsewhere on the board
A0_CH0_DQ25: U_M0a.Y11; also elsewhere on the board
A0_CH0_DQ26: U_M0a.Y12; also elsewhere on the board
A0_CH0_DQ27: U_M0a.Y13; also elsewhere on the board
A0_CH0_DQ28: U_M0a.Y14; also elsewhere on the board
A0_CH0_DQ29: U_M0a.Y15; also elsewhere on the board
A0_CH0_DQ30: U_M0a.W1; also elsewhere on the board
A0_CH0_DQ31: U_M0a.W2; also elsewhere on the board
A0_CH0_DQS0_N: U_M0a.W4; also elsewhere on the board
A0_CH0_DQS0_P: U_M0a.W3; also elsewhere on the board
A0_CH0_DQS1_N: U_M0a.W6; also elsewhere on the board
A0_CH0_DQS1_P: U_M0a.W5; also elsewhere on the board
A0_CH0_DQS2_N: U_M0a.W8; also elsewhere on the board
A0_CH0_DQS2_P: U_M0a.W7; also elsewhere on the board
A0_CH0_DQS3_N: U_M0a.W10; also elsewhere on the board
A0_CH0_DQS3_P: U_M0a.W9; also elsewhere on the board
A0_CH0_RESET: U_M0a.U5; also elsewhere on the board
A0_CH1_CA0: U_M0b.W15; also elsewhere on the board
A0_CH1_CA1: U_M0b.V1; also elsewhere on the board
A0_CH1_CA2: U_M0b.V2; also elsewhere on the board
A0_CH1_CA3: U_M0b.V3; also elsewhere on the board
A0_CH1_CA4: U_M0b.V4; also elsewhere on the board
A0_CH1_CA5: U_M0b.V5; also elsewhere on the board
A0_CH1_CA6: U_M0b.V6; also elsewhere on the board
A0_CH1_CA7: U_M0b.V7; also elsewhere on the board
A0_CH1_CA8: U_M0b.V8; also elsewhere on the board
A0_CH1_CA9: U_M0b.V9; also elsewhere on the board
A0_CH1_CA10: U_M0b.V10; also elsewhere on the board
A0_CH1_CA11: U_M0b.V11; also elsewhere on the board
A0_CH1_CA12: U_M0b.V12; also elsewhere on the board
A0_CH1_CA13: U_M0b.V13; also elsewhere on the board
A0_CH1_CK0_N: U_M0b.U2; also elsewhere on the board
A0_CH1_CK0_P: U_M0b.U1; also elsewhere on the board
A0_CH1_CK1_N: U_M0b.U4; also elsewhere on the board
A0_CH1_CK1_P: U_M0b.U3; also elsewhere on the board
A0_CH1_CS0: U_M0b.V14; also elsewhere on the board
A0_CH1_CS1: U_M0b.V15; also elsewhere on the board
A0_CH1_DMI0: U_M0b.W11; also elsewhere on the board
A0_CH1_DMI1: U_M0b.W12; also elsewhere on the board
A0_CH1_DMI2: U_M0b.W13; also elsewhere on the board
A0_CH1_DMI3: U_M0b.W14; also elsewhere on the board
A0_CH1_DQ0: U_M0b.AA1; also elsewhere on the board
A0_CH1_DQ1: U_M0b.AA2; also elsewhere on the board
A0_CH1_DQ2: U_M0b.AA3; also elsewhere on the board
A0_CH1_DQ3: U_M0b.AA4; also elsewhere on the board
A0_CH1_DQ4: U_M0b.AA5; also elsewhere on the board
A0_CH1_DQ5: U_M0b.AA6; also elsewhere on the board
A0_CH1_DQ6: U_M0b.AA7; also elsewhere on the board
A0_CH1_DQ7: U_M0b.AA8; also elsewhere on the board
A0_CH1_DQ8: U_M0b.AA9; also elsewhere on the board
A0_CH1_DQ9: U_M0b.AA10; also elsewhere on the board
A0_CH1_DQ10: U_M0b.AA11; also elsewhere on the board
A0_CH1_DQ11: U_M0b.AA12; also elsewhere on the board
A0_CH1_DQ12: U_M0b.AA13; also elsewhere on the board
A0_CH1_DQ13: U_M0b.AA14; also elsewhere on the board
A0_CH1_DQ14: U_M0b.AA15; also elsewhere on the board
A0_CH1_DQ15: U_M0b.Y1; also elsewhere on the board
A0_CH1_DQ16: U_M0b.Y2; also elsewhere on the board
A0_CH1_DQ17: U_M0b.Y3; also elsewhere on the board
A0_CH1_DQ18: U_M0b.Y4; also elsewhere on the board
A0_CH1_DQ19: U_M0b.Y5; also elsewhere on the board
A0_CH1_DQ20: U_M0b.Y6; also elsewhere on the board
A0_CH1_DQ21: U_M0b.Y7; also elsewhere on the board
A0_CH1_DQ22: U_M0b.Y8; also elsewhere on the board
A0_CH1_DQ23: U_M0b.Y9; also elsewhere on the board
A0_CH1_DQ24: U_M0b.Y10; also elsewhere on the board
A0_CH1_DQ25: U_M0b.Y11; also elsewhere on the board
A0_CH1_DQ26: U_M0b.Y12; also elsewhere on the board
A0_CH1_DQ27: U_M0b.Y13; also elsewhere on the board
A0_CH1_DQ28: U_M0b.Y14; also elsewhere on the board
A0_CH1_DQ29: U_M0b.Y15; also elsewhere on the board
A0_CH1_DQ30: U_M0b.W1; also elsewhere on the board
A0_CH1_DQ31: U_M0b.W2; also elsewhere on the board
A0_CH1_DQS0_N: U_M0b.W4; also elsewhere on the board
A0_CH1_DQS0_P: U_M0b.W3; also elsewhere on the board
A0_CH1_DQS1_N: U_M0b.W6; also elsewhere on the board
A0_CH1_DQS1_P: U_M0b.W5; also elsewhere on the board
A0_CH1_DQS2_N: U_M0b.W8; also elsewhere on the board
A0_CH1_DQS2_P: U_M0b.W7; also elsewhere on the board
A0_CH1_DQS3_N: U_M0b.W10; also elsewhere on the board
A0_CH1_DQS3_P: U_M0b.W9; also elsewhere on the board
A0_CH1_RESET: U_M0b.U5; also elsewhere on the board
A1_CH0_CA0: U_M1a.W15; also elsewhere on the board
A1_CH0_CA1: U_M1a.V1; also elsewhere on the board
A1_CH0_CA2: U_M1a.V2; also elsewhere on the board
A1_CH0_CA3: U_M1a.V3; also elsewhere on the board
A1_CH0_CA4: U_M1a.V4; also elsewhere on the board
A1_CH0_CA5: U_M1a.V5; also elsewhere on the board
A1_CH0_CA6: U_M1a.V6; also elsewhere on the board
A1_CH0_CA7: U_M1a.V7; also elsewhere on the board
A1_CH0_CA8: U_M1a.V8; also elsewhere on the board
A1_CH0_CA9: U_M1a.V9; also elsewhere on the board
A1_CH0_CA10: U_M1a.V10; also elsewhere on the board
A1_CH0_CA11: U_M1a.V11; also elsewhere on the board
A1_CH0_CA12: U_M1a.V12; also elsewhere on the board
A1_CH0_CA13: U_M1a.V13; also elsewhere on the board
A1_CH0_CK0_N: U_M1a.U2; also elsewhere on the board
A1_CH0_CK0_P: U_M1a.U1; also elsewhere on the board
A1_CH0_CK1_N: U_M1a.U4; also elsewhere on the board
A1_CH0_CK1_P: U_M1a.U3; also elsewhere on the board
A1_CH0_CS0: U_M1a.V14; also elsewhere on the board
A1_CH0_CS1: U_M1a.V15; also elsewhere on the board
A1_CH0_DMI0: U_M1a.W11; also elsewhere on the board
A1_CH0_DMI1: U_M1a.W12; also elsewhere on the board
A1_CH0_DMI2: U_M1a.W13; also elsewhere on the board
A1_CH0_DMI3: U_M1a.W14; also elsewhere on the board
A1_CH0_DQ0: U_M1a.AA1; also elsewhere on the board
A1_CH0_DQ1: U_M1a.AA2; also elsewhere on the board
A1_CH0_DQ2: U_M1a.AA3; also elsewhere on the board
A1_CH0_DQ3: U_M1a.AA4; also elsewhere on the board
A1_CH0_DQ4: U_M1a.AA5; also elsewhere on the board
A1_CH0_DQ5: U_M1a.AA6; also elsewhere on the board
A1_CH0_DQ6: U_M1a.AA7; also elsewhere on the board
A1_CH0_DQ7: U_M1a.AA8; also elsewhere on the board
A1_CH0_DQ8: U_M1a.AA9; also elsewhere on the board
A1_CH0_DQ9: U_M1a.AA10; also elsewhere on the board
A1_CH0_DQ10: U_M1a.AA11; also elsewhere on the board
A1_CH0_DQ11: U_M1a.AA12; also elsewhere on the board
A1_CH0_DQ12: U_M1a.AA13; also elsewhere on the board
A1_CH0_DQ13: U_M1a.AA14; also elsewhere on the board
A1_CH0_DQ14: U_M1a.AA15; also elsewhere on the board
A1_CH0_DQ15: U_M1a.Y1; also elsewhere on the board
A1_CH0_DQ16: U_M1a.Y2; also elsewhere on the board
A1_CH0_DQ17: U_M1a.Y3; also elsewhere on the board
A1_CH0_DQ18: U_M1a.Y4; also elsewhere on the board
A1_CH0_DQ19: U_M1a.Y5; also elsewhere on the board
A1_CH0_DQ20: U_M1a.Y6; also elsewhere on the board
A1_CH0_DQ21: U_M1a.Y7; also elsewhere on the board
A1_CH0_DQ22: U_M1a.Y8; also elsewhere on the board
A1_CH0_DQ23: U_M1a.Y9; also elsewhere on the board
A1_CH0_DQ24: U_M1a.Y10; also elsewhere on the board
A1_CH0_DQ25: U_M1a.Y11; also elsewhere on the board
A1_CH0_DQ26: U_M1a.Y12; also elsewhere on the board
A1_CH0_DQ27: U_M1a.Y13; also elsewhere on the board
A1_CH0_DQ28: U_M1a.Y14; also elsewhere on the board
A1_CH0_DQ29: U_M1a.Y15; also elsewhere on the board
A1_CH0_DQ30: U_M1a.W1; also elsewhere on the board
A1_CH0_DQ31: U_M1a.W2; also elsewhere on the board
A1_CH0_DQS0_N: U_M1a.W4; also elsewhere on the board
A1_CH0_DQS0_P: U_M1a.W3; also elsewhere on the board
A1_CH0_DQS1_N: U_M1a.W6; also elsewhere on the board
A1_CH0_DQS1_P: U_M1a.W5; also elsewhere on the board
A1_CH0_DQS2_N: U_M1a.W8; also elsewhere on the board
A1_CH0_DQS2_P: U_M1a.W7; also elsewhere on the board
A1_CH0_DQS3_N: U_M1a.W10; also elsewhere on the board
A1_CH0_DQS3_P: U_M1a.W9; also elsewhere on the board
A1_CH0_RESET: U_M1a.U5; also elsewhere on the board
A1_CH1_CA0: U_M1b.W15; also elsewhere on the board
A1_CH1_CA1: U_M1b.V1; also elsewhere on the board
A1_CH1_CA2: U_M1b.V2; also elsewhere on the board
A1_CH1_CA3: U_M1b.V3; also elsewhere on the board
A1_CH1_CA4: U_M1b.V4; also elsewhere on the board
A1_CH1_CA5: U_M1b.V5; also elsewhere on the board
A1_CH1_CA6: U_M1b.V6; also elsewhere on the board
A1_CH1_CA7: U_M1b.V7; also elsewhere on the board
A1_CH1_CA8: U_M1b.V8; also elsewhere on the board
A1_CH1_CA9: U_M1b.V9; also elsewhere on the board
A1_CH1_CA10: U_M1b.V10; also elsewhere on the board
A1_CH1_CA11: U_M1b.V11; also elsewhere on the board
A1_CH1_CA12: U_M1b.V12; also elsewhere on the board
A1_CH1_CA13: U_M1b.V13; also elsewhere on the board
A1_CH1_CK0_N: U_M1b.U2; also elsewhere on the board
A1_CH1_CK0_P: U_M1b.U1; also elsewhere on the board
A1_CH1_CK1_N: U_M1b.U4; also elsewhere on the board
A1_CH1_CK1_P: U_M1b.U3; also elsewhere on the board
A1_CH1_CS0: U_M1b.V14; also elsewhere on the board
A1_CH1_CS1: U_M1b.V15; also elsewhere on the board
A1_CH1_DMI0: U_M1b.W11; also elsewhere on the board
A1_CH1_DMI1: U_M1b.W12; also elsewhere on the board
A1_CH1_DMI2: U_M1b.W13; also elsewhere on the board
A1_CH1_DMI3: U_M1b.W14; also elsewhere on the board
A1_CH1_DQ0: U_M1b.AA1; also elsewhere on the board
A1_CH1_DQ1: U_M1b.AA2; also elsewhere on the board
A1_CH1_DQ2: U_M1b.AA3; also elsewhere on the board
A1_CH1_DQ3: U_M1b.AA4; also elsewhere on the board
A1_CH1_DQ4: U_M1b.AA5; also elsewhere on the board
A1_CH1_DQ5: U_M1b.AA6; also elsewhere on the board
A1_CH1_DQ6: U_M1b.AA7; also elsewhere on the board
A1_CH1_DQ7: U_M1b.AA8; also elsewhere on the board
A1_CH1_DQ8: U_M1b.AA9; also elsewhere on the board
A1_CH1_DQ9: U_M1b.AA10; also elsewhere on the board
A1_CH1_DQ10: U_M1b.AA11; also elsewhere on the board
A1_CH1_DQ11: U_M1b.AA12; also elsewhere on the board
A1_CH1_DQ12: U_M1b.AA13; also elsewhere on the board
A1_CH1_DQ13: U_M1b.AA14; also elsewhere on the board
A1_CH1_DQ14: U_M1b.AA15; also elsewhere on the board
A1_CH1_DQ15: U_M1b.Y1; also elsewhere on the board
A1_CH1_DQ16: U_M1b.Y2; also elsewhere on the board
A1_CH1_DQ17: U_M1b.Y3; also elsewhere on the board
A1_CH1_DQ18: U_M1b.Y4; also elsewhere on the board
A1_CH1_DQ19: U_M1b.Y5; also elsewhere on the board
A1_CH1_DQ20: U_M1b.Y6; also elsewhere on the board
A1_CH1_DQ21: U_M1b.Y7; also elsewhere on the board
A1_CH1_DQ22: U_M1b.Y8; also elsewhere on the board
A1_CH1_DQ23: U_M1b.Y9; also elsewhere on the board
A1_CH1_DQ24: U_M1b.Y10; also elsewhere on the board
A1_CH1_DQ25: U_M1b.Y11; also elsewhere on the board
A1_CH1_DQ26: U_M1b.Y12; also elsewhere on the board
A1_CH1_DQ27: U_M1b.Y13; also elsewhere on the board
A1_CH1_DQ28: U_M1b.Y14; also elsewhere on the board
A1_CH1_DQ29: U_M1b.Y15; also elsewhere on the board
A1_CH1_DQ30: U_M1b.W1; also elsewhere on the board
A1_CH1_DQ31: U_M1b.W2; also elsewhere on the board
A1_CH1_DQS0_N: U_M1b.W4; also elsewhere on the board
A1_CH1_DQS0_P: U_M1b.W3; also elsewhere on the board
A1_CH1_DQS1_N: U_M1b.W6; also elsewhere on the board
A1_CH1_DQS1_P: U_M1b.W5; also elsewhere on the board
A1_CH1_DQS2_N: U_M1b.W8; also elsewhere on the board
A1_CH1_DQS2_P: U_M1b.W7; also elsewhere on the board
A1_CH1_DQS3_N: U_M1b.W10; also elsewhere on the board
A1_CH1_DQS3_P: U_M1b.W9; also elsewhere on the board
A1_CH1_RESET: U_M1b.U5; also elsewhere on the board
A2_CH0_CA0: U_M2a.W15; also elsewhere on the board
A2_CH0_CA1: U_M2a.V1; also elsewhere on the board
A2_CH0_CA2: U_M2a.V2; also elsewhere on the board
A2_CH0_CA3: U_M2a.V3; also elsewhere on the board
A2_CH0_CA4: U_M2a.V4; also elsewhere on the board
A2_CH0_CA5: U_M2a.V5; also elsewhere on the board
A2_CH0_CA6: U_M2a.V6; also elsewhere on the board
A2_CH0_CA7: U_M2a.V7; also elsewhere on the board
A2_CH0_CA8: U_M2a.V8; also elsewhere on the board
A2_CH0_CA9: U_M2a.V9; also elsewhere on the board
A2_CH0_CA10: U_M2a.V10; also elsewhere on the board
A2_CH0_CA11: U_M2a.V11; also elsewhere on the board
A2_CH0_CA12: U_M2a.V12; also elsewhere on the board
A2_CH0_CA13: U_M2a.V13; also elsewhere on the board
A2_CH0_CK0_N: U_M2a.U2; also elsewhere on the board
A2_CH0_CK0_P: U_M2a.U1; also elsewhere on the board
A2_CH0_CK1_N: U_M2a.U4; also elsewhere on the board
A2_CH0_CK1_P: U_M2a.U3; also elsewhere on the board
A2_CH0_CS0: U_M2a.V14; also elsewhere on the board
A2_CH0_CS1: U_M2a.V15; also elsewhere on the board
A2_CH0_DMI0: U_M2a.W11; also elsewhere on the board
A2_CH0_DMI1: U_M2a.W12; also elsewhere on the board
A2_CH0_DMI2: U_M2a.W13; also elsewhere on the board
A2_CH0_DMI3: U_M2a.W14; also elsewhere on the board
A2_CH0_DQ0: U_M2a.AA1; also elsewhere on the board
A2_CH0_DQ1: U_M2a.AA2; also elsewhere on the board
A2_CH0_DQ2: U_M2a.AA3; also elsewhere on the board
A2_CH0_DQ3: U_M2a.AA4; also elsewhere on the board
A2_CH0_DQ4: U_M2a.AA5; also elsewhere on the board
A2_CH0_DQ5: U_M2a.AA6; also elsewhere on the board
A2_CH0_DQ6: U_M2a.AA7; also elsewhere on the board
A2_CH0_DQ7: U_M2a.AA8; also elsewhere on the board
A2_CH0_DQ8: U_M2a.AA9; also elsewhere on the board
A2_CH0_DQ9: U_M2a.AA10; also elsewhere on the board
A2_CH0_DQ10: U_M2a.AA11; also elsewhere on the board
A2_CH0_DQ11: U_M2a.AA12; also elsewhere on the board
A2_CH0_DQ12: U_M2a.AA13; also elsewhere on the board
A2_CH0_DQ13: U_M2a.AA14; also elsewhere on the board
A2_CH0_DQ14: U_M2a.AA15; also elsewhere on the board
A2_CH0_DQ15: U_M2a.Y1; also elsewhere on the board
A2_CH0_DQ16: U_M2a.Y2; also elsewhere on the board
A2_CH0_DQ17: U_M2a.Y3; also elsewhere on the board
A2_CH0_DQ18: U_M2a.Y4; also elsewhere on the board
A2_CH0_DQ19: U_M2a.Y5; also elsewhere on the board
A2_CH0_DQ20: U_M2a.Y6; also elsewhere on the board
A2_CH0_DQ21: U_M2a.Y7; also elsewhere on the board
A2_CH0_DQ22: U_M2a.Y8; also elsewhere on the board
A2_CH0_DQ23: U_M2a.Y9; also elsewhere on the board
A2_CH0_DQ24: U_M2a.Y10; also elsewhere on the board
A2_CH0_DQ25: U_M2a.Y11; also elsewhere on the board
A2_CH0_DQ26: U_M2a.Y12; also elsewhere on the board
A2_CH0_DQ27: U_M2a.Y13; also elsewhere on the board
A2_CH0_DQ28: U_M2a.Y14; also elsewhere on the board
A2_CH0_DQ29: U_M2a.Y15; also elsewhere on the board
A2_CH0_DQ30: U_M2a.W1; also elsewhere on the board
A2_CH0_DQ31: U_M2a.W2; also elsewhere on the board
A2_CH0_DQS0_N: U_M2a.W4; also elsewhere on the board
A2_CH0_DQS0_P: U_M2a.W3; also elsewhere on the board
A2_CH0_DQS1_N: U_M2a.W6; also elsewhere on the board
A2_CH0_DQS1_P: U_M2a.W5; also elsewhere on the board
A2_CH0_DQS2_N: U_M2a.W8; also elsewhere on the board
A2_CH0_DQS2_P: U_M2a.W7; also elsewhere on the board
A2_CH0_DQS3_N: U_M2a.W10; also elsewhere on the board
A2_CH0_DQS3_P: U_M2a.W9; also elsewhere on the board
A2_CH0_RESET: U_M2a.U5; also elsewhere on the board
A2_CH1_CA0: U_M2b.W15; also elsewhere on the board
A2_CH1_CA1: U_M2b.V1; also elsewhere on the board
A2_CH1_CA2: U_M2b.V2; also elsewhere on the board
A2_CH1_CA3: U_M2b.V3; also elsewhere on the board
A2_CH1_CA4: U_M2b.V4; also elsewhere on the board
A2_CH1_CA5: U_M2b.V5; also elsewhere on the board
A2_CH1_CA6: U_M2b.V6; also elsewhere on the board
A2_CH1_CA7: U_M2b.V7; also elsewhere on the board
A2_CH1_CA8: U_M2b.V8; also elsewhere on the board
A2_CH1_CA9: U_M2b.V9; also elsewhere on the board
A2_CH1_CA10: U_M2b.V10; also elsewhere on the board
A2_CH1_CA11: U_M2b.V11; also elsewhere on the board
A2_CH1_CA12: U_M2b.V12; also elsewhere on the board
A2_CH1_CA13: U_M2b.V13; also elsewhere on the board
A2_CH1_CK0_N: U_M2b.U2; also elsewhere on the board
A2_CH1_CK0_P: U_M2b.U1; also elsewhere on the board
A2_CH1_CK1_N: U_M2b.U4; also elsewhere on the board
A2_CH1_CK1_P: U_M2b.U3; also elsewhere on the board
A2_CH1_CS0: U_M2b.V14; also elsewhere on the board
A2_CH1_CS1: U_M2b.V15; also elsewhere on the board
A2_CH1_DMI0: U_M2b.W11; also elsewhere on the board
A2_CH1_DMI1: U_M2b.W12; also elsewhere on the board
A2_CH1_DMI2: U_M2b.W13; also elsewhere on the board
A2_CH1_DMI3: U_M2b.W14; also elsewhere on the board
A2_CH1_DQ0: U_M2b.AA1; also elsewhere on the board
A2_CH1_DQ1: U_M2b.AA2; also elsewhere on the board
A2_CH1_DQ2: U_M2b.AA3; also elsewhere on the board
A2_CH1_DQ3: U_M2b.AA4; also elsewhere on the board
A2_CH1_DQ4: U_M2b.AA5; also elsewhere on the board
A2_CH1_DQ5: U_M2b.AA6; also elsewhere on the board
A2_CH1_DQ6: U_M2b.AA7; also elsewhere on the board
A2_CH1_DQ7: U_M2b.AA8; also elsewhere on the board
A2_CH1_DQ8: U_M2b.AA9; also elsewhere on the board
A2_CH1_DQ9: U_M2b.AA10; also elsewhere on the board
A2_CH1_DQ10: U_M2b.AA11; also elsewhere on the board
A2_CH1_DQ11: U_M2b.AA12; also elsewhere on the board
A2_CH1_DQ12: U_M2b.AA13; also elsewhere on the board
A2_CH1_DQ13: U_M2b.AA14; also elsewhere on the board
A2_CH1_DQ14: U_M2b.AA15; also elsewhere on the board
A2_CH1_DQ15: U_M2b.Y1; also elsewhere on the board
A2_CH1_DQ16: U_M2b.Y2; also elsewhere on the board
A2_CH1_DQ17: U_M2b.Y3; also elsewhere on the board
A2_CH1_DQ18: U_M2b.Y4; also elsewhere on the board
A2_CH1_DQ19: U_M2b.Y5; also elsewhere on the board
A2_CH1_DQ20: U_M2b.Y6; also elsewhere on the board
A2_CH1_DQ21: U_M2b.Y7; also elsewhere on the board
A2_CH1_DQ22: U_M2b.Y8; also elsewhere on the board
A2_CH1_DQ23: U_M2b.Y9; also elsewhere on the board
A2_CH1_DQ24: U_M2b.Y10; also elsewhere on the board
A2_CH1_DQ25: U_M2b.Y11; also elsewhere on the board
A2_CH1_DQ26: U_M2b.Y12; also elsewhere on the board
A2_CH1_DQ27: U_M2b.Y13; also elsewhere on the board
A2_CH1_DQ28: U_M2b.Y14; also elsewhere on the board
A2_CH1_DQ29: U_M2b.Y15; also elsewhere on the board
A2_CH1_DQ30: U_M2b.W1; also elsewhere on the board
A2_CH1_DQ31: U_M2b.W2; also elsewhere on the board
A2_CH1_DQS0_N: U_M2b.W4; also elsewhere on the board
A2_CH1_DQS0_P: U_M2b.W3; also elsewhere on the board
A2_CH1_DQS1_N: U_M2b.W6; also elsewhere on the board
A2_CH1_DQS1_P: U_M2b.W5; also elsewhere on the board
A2_CH1_DQS2_N: U_M2b.W8; also elsewhere on the board
A2_CH1_DQS2_P: U_M2b.W7; also elsewhere on the board
A2_CH1_DQS3_N: U_M2b.W10; also elsewhere on the board
A2_CH1_DQS3_P: U_M2b.W9; also elsewhere on the board
A2_CH1_RESET: U_M2b.U5; also elsewhere on the board
A3_CH0_CA0: U_M3a.W15; also elsewhere on the board
A3_CH0_CA1: U_M3a.V1; also elsewhere on the board
A3_CH0_CA2: U_M3a.V2; also elsewhere on the board
A3_CH0_CA3: U_M3a.V3; also elsewhere on the board
A3_CH0_CA4: U_M3a.V4; also elsewhere on the board
A3_CH0_CA5: U_M3a.V5; also elsewhere on the board
A3_CH0_CA6: U_M3a.V6; also elsewhere on the board
A3_CH0_CA7: U_M3a.V7; also elsewhere on the board
A3_CH0_CA8: U_M3a.V8; also elsewhere on the board
A3_CH0_CA9: U_M3a.V9; also elsewhere on the board
A3_CH0_CA10: U_M3a.V10; also elsewhere on the board
A3_CH0_CA11: U_M3a.V11; also elsewhere on the board
A3_CH0_CA12: U_M3a.V12; also elsewhere on the board
A3_CH0_CA13: U_M3a.V13; also elsewhere on the board
A3_CH0_CK0_N: U_M3a.U2; also elsewhere on the board
A3_CH0_CK0_P: U_M3a.U1; also elsewhere on the board
A3_CH0_CK1_N: U_M3a.U4; also elsewhere on the board
A3_CH0_CK1_P: U_M3a.U3; also elsewhere on the board
A3_CH0_CS0: U_M3a.V14; also elsewhere on the board
A3_CH0_CS1: U_M3a.V15; also elsewhere on the board
A3_CH0_DMI0: U_M3a.W11; also elsewhere on the board
A3_CH0_DMI1: U_M3a.W12; also elsewhere on the board
A3_CH0_DMI2: U_M3a.W13; also elsewhere on the board
A3_CH0_DMI3: U_M3a.W14; also elsewhere on the board
A3_CH0_DQ0: U_M3a.AA1; also elsewhere on the board
A3_CH0_DQ1: U_M3a.AA2; also elsewhere on the board
A3_CH0_DQ2: U_M3a.AA3; also elsewhere on the board
A3_CH0_DQ3: U_M3a.AA4; also elsewhere on the board
A3_CH0_DQ4: U_M3a.AA5; also elsewhere on the board
A3_CH0_DQ5: U_M3a.AA6; also elsewhere on the board
A3_CH0_DQ6: U_M3a.AA7; also elsewhere on the board
A3_CH0_DQ7: U_M3a.AA8; also elsewhere on the board
A3_CH0_DQ8: U_M3a.AA9; also elsewhere on the board
A3_CH0_DQ9: U_M3a.AA10; also elsewhere on the board
A3_CH0_DQ10: U_M3a.AA11; also elsewhere on the board
A3_CH0_DQ11: U_M3a.AA12; also elsewhere on the board
A3_CH0_DQ12: U_M3a.AA13; also elsewhere on the board
A3_CH0_DQ13: U_M3a.AA14; also elsewhere on the board
A3_CH0_DQ14: U_M3a.AA15; also elsewhere on the board
A3_CH0_DQ15: U_M3a.Y1; also elsewhere on the board
A3_CH0_DQ16: U_M3a.Y2; also elsewhere on the board
A3_CH0_DQ17: U_M3a.Y3; also elsewhere on the board
A3_CH0_DQ18: U_M3a.Y4; also elsewhere on the board
A3_CH0_DQ19: U_M3a.Y5; also elsewhere on the board
A3_CH0_DQ20: U_M3a.Y6; also elsewhere on the board
A3_CH0_DQ21: U_M3a.Y7; also elsewhere on the board
A3_CH0_DQ22: U_M3a.Y8; also elsewhere on the board
A3_CH0_DQ23: U_M3a.Y9; also elsewhere on the board
A3_CH0_DQ24: U_M3a.Y10; also elsewhere on the board
A3_CH0_DQ25: U_M3a.Y11; also elsewhere on the board
A3_CH0_DQ26: U_M3a.Y12; also elsewhere on the board
A3_CH0_DQ27: U_M3a.Y13; also elsewhere on the board
A3_CH0_DQ28: U_M3a.Y14; also elsewhere on the board
A3_CH0_DQ29: U_M3a.Y15; also elsewhere on the board
A3_CH0_DQ30: U_M3a.W1; also elsewhere on the board
A3_CH0_DQ31: U_M3a.W2; also elsewhere on the board
A3_CH0_DQS0_N: U_M3a.W4; also elsewhere on the board
A3_CH0_DQS0_P: U_M3a.W3; also elsewhere on the board
A3_CH0_DQS1_N: U_M3a.W6; also elsewhere on the board
A3_CH0_DQS1_P: U_M3a.W5; also elsewhere on the board
A3_CH0_DQS2_N: U_M3a.W8; also elsewhere on the board
A3_CH0_DQS2_P: U_M3a.W7; also elsewhere on the board
A3_CH0_DQS3_N: U_M3a.W10; also elsewhere on the board
A3_CH0_DQS3_P: U_M3a.W9; also elsewhere on the board
A3_CH0_RESET: U_M3a.U5; also elsewhere on the board
A3_CH1_CA0: U_M3b.W15; also elsewhere on the board
A3_CH1_CA1: U_M3b.V1; also elsewhere on the board
A3_CH1_CA2: U_M3b.V2; also elsewhere on the board
A3_CH1_CA3: U_M3b.V3; also elsewhere on the board
A3_CH1_CA4: U_M3b.V4; also elsewhere on the board
A3_CH1_CA5: U_M3b.V5; also elsewhere on the board
A3_CH1_CA6: U_M3b.V6; also elsewhere on the board
A3_CH1_CA7: U_M3b.V7; also elsewhere on the board
A3_CH1_CA8: U_M3b.V8; also elsewhere on the board
A3_CH1_CA9: U_M3b.V9; also elsewhere on the board
A3_CH1_CA10: U_M3b.V10; also elsewhere on the board
A3_CH1_CA11: U_M3b.V11; also elsewhere on the board
A3_CH1_CA12: U_M3b.V12; also elsewhere on the board
A3_CH1_CA13: U_M3b.V13; also elsewhere on the board
A3_CH1_CK0_N: U_M3b.U2; also elsewhere on the board
A3_CH1_CK0_P: U_M3b.U1; also elsewhere on the board
A3_CH1_CK1_N: U_M3b.U4; also elsewhere on the board
A3_CH1_CK1_P: U_M3b.U3; also elsewhere on the board
A3_CH1_CS0: U_M3b.V14; also elsewhere on the board
A3_CH1_CS1: U_M3b.V15; also elsewhere on the board
A3_CH1_DMI0: U_M3b.W11; also elsewhere on the board
A3_CH1_DMI1: U_M3b.W12; also elsewhere on the board
A3_CH1_DMI2: U_M3b.W13; also elsewhere on the board
A3_CH1_DMI3: U_M3b.W14; also elsewhere on the board
A3_CH1_DQ0: U_M3b.AA1; also elsewhere on the board
A3_CH1_DQ1: U_M3b.AA2; also elsewhere on the board
A3_CH1_DQ2: U_M3b.AA3; also elsewhere on the board
A3_CH1_DQ3: U_M3b.AA4; also elsewhere on the board
A3_CH1_DQ4: U_M3b.AA5; also elsewhere on the board
A3_CH1_DQ5: U_M3b.AA6; also elsewhere on the board
A3_CH1_DQ6: U_M3b.AA7; also elsewhere on the board
A3_CH1_DQ7: U_M3b.AA8; also elsewhere on the board
A3_CH1_DQ8: U_M3b.AA9; also elsewhere on the board
A3_CH1_DQ9: U_M3b.AA10; also elsewhere on the board
A3_CH1_DQ10: U_M3b.AA11; also elsewhere on the board
A3_CH1_DQ11: U_M3b.AA12; also elsewhere on the board
A3_CH1_DQ12: U_M3b.AA13; also elsewhere on the board
A3_CH1_DQ13: U_M3b.AA14; also elsewhere on the board
A3_CH1_DQ14: U_M3b.AA15; also elsewhere on the board
A3_CH1_DQ15: U_M3b.Y1; also elsewhere on the board
A3_CH1_DQ16: U_M3b.Y2; also elsewhere on the board
A3_CH1_DQ17: U_M3b.Y3; also elsewhere on the board
A3_CH1_DQ18: U_M3b.Y4; also elsewhere on the board
A3_CH1_DQ19: U_M3b.Y5; also elsewhere on the board
A3_CH1_DQ20: U_M3b.Y6; also elsewhere on the board
A3_CH1_DQ21: U_M3b.Y7; also elsewhere on the board
A3_CH1_DQ22: U_M3b.Y8; also elsewhere on the board
A3_CH1_DQ23: U_M3b.Y9; also elsewhere on the board
A3_CH1_DQ24: U_M3b.Y10; also elsewhere on the board
A3_CH1_DQ25: U_M3b.Y11; also elsewhere on the board
A3_CH1_DQ26: U_M3b.Y12; also elsewhere on the board
A3_CH1_DQ27: U_M3b.Y13; also elsewhere on the board
A3_CH1_DQ28: U_M3b.Y14; also elsewhere on the board
A3_CH1_DQ29: U_M3b.Y15; also elsewhere on the board
A3_CH1_DQ30: U_M3b.W1; also elsewhere on the board
A3_CH1_DQ31: U_M3b.W2; also elsewhere on the board
A3_CH1_DQS0_N: U_M3b.W4; also elsewhere on the board
A3_CH1_DQS0_P: U_M3b.W3; also elsewhere on the board
A3_CH1_DQS1_N: U_M3b.W6; also elsewhere on the board
A3_CH1_DQS1_P: U_M3b.W5; also elsewhere on the board
A3_CH1_DQS2_N: U_M3b.W8; also elsewhere on the board
A3_CH1_DQS2_P: U_M3b.W7; also elsewhere on the board
A3_CH1_DQS3_N: U_M3b.W10; also elsewhere on the board
A3_CH1_DQS3_P: U_M3b.W9; also elsewhere on the board
A3_CH1_RESET: U_M3b.U5; also elsewhere on the board
A4_CH0_CA0: U_M4a.W15; also elsewhere on the board
A4_CH0_CA1: U_M4a.V1; also elsewhere on the board
A4_CH0_CA2: U_M4a.V2; also elsewhere on the board
A4_CH0_CA3: U_M4a.V3; also elsewhere on the board
A4_CH0_CA4: U_M4a.V4; also elsewhere on the board
A4_CH0_CA5: U_M4a.V5; also elsewhere on the board
A4_CH0_CA6: U_M4a.V6; also elsewhere on the board
A4_CH0_CA7: U_M4a.V7; also elsewhere on the board
A4_CH0_CA8: U_M4a.V8; also elsewhere on the board
A4_CH0_CA9: U_M4a.V9; also elsewhere on the board
A4_CH0_CA10: U_M4a.V10; also elsewhere on the board
A4_CH0_CA11: U_M4a.V11; also elsewhere on the board
A4_CH0_CA12: U_M4a.V12; also elsewhere on the board
A4_CH0_CA13: U_M4a.V13; also elsewhere on the board
A4_CH0_CK0_N: U_M4a.U2; also elsewhere on the board
A4_CH0_CK0_P: U_M4a.U1; also elsewhere on the board
A4_CH0_CK1_N: U_M4a.U4; also elsewhere on the board
A4_CH0_CK1_P: U_M4a.U3; also elsewhere on the board
A4_CH0_CS0: U_M4a.V14; also elsewhere on the board
A4_CH0_CS1: U_M4a.V15; also elsewhere on the board
A4_CH0_DMI0: U_M4a.W11; also elsewhere on the board
A4_CH0_DMI1: U_M4a.W12; also elsewhere on the board
A4_CH0_DMI2: U_M4a.W13; also elsewhere on the board
A4_CH0_DMI3: U_M4a.W14; also elsewhere on the board
A4_CH0_DQ0: U_M4a.AA1; also elsewhere on the board
A4_CH0_DQ1: U_M4a.AA2; also elsewhere on the board
A4_CH0_DQ2: U_M4a.AA3; also elsewhere on the board
A4_CH0_DQ3: U_M4a.AA4; also elsewhere on the board
A4_CH0_DQ4: U_M4a.AA5; also elsewhere on the board
A4_CH0_DQ5: U_M4a.AA6; also elsewhere on the board
A4_CH0_DQ6: U_M4a.AA7; also elsewhere on the board
A4_CH0_DQ7: U_M4a.AA8; also elsewhere on the board
A4_CH0_DQ8: U_M4a.AA9; also elsewhere on the board
A4_CH0_DQ9: U_M4a.AA10; also elsewhere on the board
A4_CH0_DQ10: U_M4a.AA11; also elsewhere on the board
A4_CH0_DQ11: U_M4a.AA12; also elsewhere on the board
A4_CH0_DQ12: U_M4a.AA13; also elsewhere on the board
A4_CH0_DQ13: U_M4a.AA14; also elsewhere on the board
A4_CH0_DQ14: U_M4a.AA15; also elsewhere on the board
A4_CH0_DQ15: U_M4a.Y1; also elsewhere on the board
A4_CH0_DQ16: U_M4a.Y2; also elsewhere on the board
A4_CH0_DQ17: U_M4a.Y3; also elsewhere on the board
A4_CH0_DQ18: U_M4a.Y4; also elsewhere on the board
A4_CH0_DQ19: U_M4a.Y5; also elsewhere on the board
A4_CH0_DQ20: U_M4a.Y6; also elsewhere on the board
A4_CH0_DQ21: U_M4a.Y7; also elsewhere on the board
A4_CH0_DQ22: U_M4a.Y8; also elsewhere on the board
A4_CH0_DQ23: U_M4a.Y9; also elsewhere on the board
A4_CH0_DQ24: U_M4a.Y10; also elsewhere on the board
A4_CH0_DQ25: U_M4a.Y11; also elsewhere on the board
A4_CH0_DQ26: U_M4a.Y12; also elsewhere on the board
A4_CH0_DQ27: U_M4a.Y13; also elsewhere on the board
A4_CH0_DQ28: U_M4a.Y14; also elsewhere on the board
A4_CH0_DQ29: U_M4a.Y15; also elsewhere on the board
A4_CH0_DQ30: U_M4a.W1; also elsewhere on the board
A4_CH0_DQ31: U_M4a.W2; also elsewhere on the board
A4_CH0_DQS0_N: U_M4a.W4; also elsewhere on the board
A4_CH0_DQS0_P: U_M4a.W3; also elsewhere on the board
A4_CH0_DQS1_N: U_M4a.W6; also elsewhere on the board
A4_CH0_DQS1_P: U_M4a.W5; also elsewhere on the board
A4_CH0_DQS2_N: U_M4a.W8; also elsewhere on the board
A4_CH0_DQS2_P: U_M4a.W7; also elsewhere on the board
A4_CH0_DQS3_N: U_M4a.W10; also elsewhere on the board
A4_CH0_DQS3_P: U_M4a.W9; also elsewhere on the board
A4_CH0_RESET: U_M4a.U5; also elsewhere on the board
A4_CH1_CA0: U_M4b.W15; also elsewhere on the board
A4_CH1_CA1: U_M4b.V1; also elsewhere on the board
A4_CH1_CA2: U_M4b.V2; also elsewhere on the board
A4_CH1_CA3: U_M4b.V3; also elsewhere on the board
A4_CH1_CA4: U_M4b.V4; also elsewhere on the board
A4_CH1_CA5: U_M4b.V5; also elsewhere on the board
A4_CH1_CA6: U_M4b.V6; also elsewhere on the board
A4_CH1_CA7: U_M4b.V7; also elsewhere on the board
A4_CH1_CA8: U_M4b.V8; also elsewhere on the board
A4_CH1_CA9: U_M4b.V9; also elsewhere on the board
A4_CH1_CA10: U_M4b.V10; also elsewhere on the board
A4_CH1_CA11: U_M4b.V11; also elsewhere on the board
A4_CH1_CA12: U_M4b.V12; also elsewhere on the board
A4_CH1_CA13: U_M4b.V13; also elsewhere on the board
A4_CH1_CK0_N: U_M4b.U2; also elsewhere on the board
A4_CH1_CK0_P: U_M4b.U1; also elsewhere on the board
A4_CH1_CK1_N: U_M4b.U4; also elsewhere on the board
A4_CH1_CK1_P: U_M4b.U3; also elsewhere on the board
A4_CH1_CS0: U_M4b.V14; also elsewhere on the board
A4_CH1_CS1: U_M4b.V15; also elsewhere on the board
A4_CH1_DMI0: U_M4b.W11; also elsewhere on the board
A4_CH1_DMI1: U_M4b.W12; also elsewhere on the board
A4_CH1_DMI2: U_M4b.W13; also elsewhere on the board
A4_CH1_DMI3: U_M4b.W14; also elsewhere on the board
A4_CH1_DQ0: U_M4b.AA1; also elsewhere on the board
A4_CH1_DQ1: U_M4b.AA2; also elsewhere on the board
A4_CH1_DQ2: U_M4b.AA3; also elsewhere on the board
A4_CH1_DQ3: U_M4b.AA4; also elsewhere on the board
A4_CH1_DQ4: U_M4b.AA5; also elsewhere on the board
A4_CH1_DQ5: U_M4b.AA6; also elsewhere on the board
A4_CH1_DQ6: U_M4b.AA7; also elsewhere on the board
A4_CH1_DQ7: U_M4b.AA8; also elsewhere on the board
A4_CH1_DQ8: U_M4b.AA9; also elsewhere on the board
A4_CH1_DQ9: U_M4b.AA10; also elsewhere on the board
A4_CH1_DQ10: U_M4b.AA11; also elsewhere on the board
A4_CH1_DQ11: U_M4b.AA12; also elsewhere on the board
A4_CH1_DQ12: U_M4b.AA13; also elsewhere on the board
A4_CH1_DQ13: U_M4b.AA14; also elsewhere on the board
A4_CH1_DQ14: U_M4b.AA15; also elsewhere on the board
A4_CH1_DQ15: U_M4b.Y1; also elsewhere on the board
A4_CH1_DQ16: U_M4b.Y2; also elsewhere on the board
A4_CH1_DQ17: U_M4b.Y3; also elsewhere on the board
A4_CH1_DQ18: U_M4b.Y4; also elsewhere on the board
A4_CH1_DQ19: U_M4b.Y5; also elsewhere on the board
A4_CH1_DQ20: U_M4b.Y6; also elsewhere on the board
A4_CH1_DQ21: U_M4b.Y7; also elsewhere on the board
A4_CH1_DQ22: U_M4b.Y8; also elsewhere on the board
A4_CH1_DQ23: U_M4b.Y9; also elsewhere on the board
A4_CH1_DQ24: U_M4b.Y10; also elsewhere on the board
A4_CH1_DQ25: U_M4b.Y11; also elsewhere on the board
A4_CH1_DQ26: U_M4b.Y12; also elsewhere on the board
A4_CH1_DQ27: U_M4b.Y13; also elsewhere on the board
A4_CH1_DQ28: U_M4b.Y14; also elsewhere on the board
A4_CH1_DQ29: U_M4b.Y15; also elsewhere on the board
A4_CH1_DQ30: U_M4b.W1; also elsewhere on the board
A4_CH1_DQ31: U_M4b.W2; also elsewhere on the board
A4_CH1_DQS0_N: U_M4b.W4; also elsewhere on the board
A4_CH1_DQS0_P: U_M4b.W3; also elsewhere on the board
A4_CH1_DQS1_N: U_M4b.W6; also elsewhere on the board
A4_CH1_DQS1_P: U_M4b.W5; also elsewhere on the board
A4_CH1_DQS2_N: U_M4b.W8; also elsewhere on the board
A4_CH1_DQS2_P: U_M4b.W7; also elsewhere on the board
A4_CH1_DQS3_N: U_M4b.W10; also elsewhere on the board
A4_CH1_DQS3_P: U_M4b.W9; also elsewhere on the board
A4_CH1_RESET: U_M4b.U5; also elsewhere on the board
A5_CH0_CA0: U_M5a.W15; also elsewhere on the board
A5_CH0_CA1: U_M5a.V1; also elsewhere on the board
A5_CH0_CA2: U_M5a.V2; also elsewhere on the board
A5_CH0_CA3: U_M5a.V3; also elsewhere on the board
A5_CH0_CA4: U_M5a.V4; also elsewhere on the board
A5_CH0_CA5: U_M5a.V5; also elsewhere on the board
A5_CH0_CA6: U_M5a.V6; also elsewhere on the board
A5_CH0_CA7: U_M5a.V7; also elsewhere on the board
A5_CH0_CA8: U_M5a.V8; also elsewhere on the board
A5_CH0_CA9: U_M5a.V9; also elsewhere on the board
A5_CH0_CA10: U_M5a.V10; also elsewhere on the board
A5_CH0_CA11: U_M5a.V11; also elsewhere on the board
A5_CH0_CA12: U_M5a.V12; also elsewhere on the board
A5_CH0_CA13: U_M5a.V13; also elsewhere on the board
A5_CH0_CK0_N: U_M5a.U2; also elsewhere on the board
A5_CH0_CK0_P: U_M5a.U1; also elsewhere on the board
A5_CH0_CK1_N: U_M5a.U4; also elsewhere on the board
A5_CH0_CK1_P: U_M5a.U3; also elsewhere on the board
A5_CH0_CS0: U_M5a.V14; also elsewhere on the board
A5_CH0_CS1: U_M5a.V15; also elsewhere on the board
A5_CH0_DMI0: U_M5a.W11; also elsewhere on the board
A5_CH0_DMI1: U_M5a.W12; also elsewhere on the board
A5_CH0_DMI2: U_M5a.W13; also elsewhere on the board
A5_CH0_DMI3: U_M5a.W14; also elsewhere on the board
A5_CH0_DQ0: U_M5a.AA1; also elsewhere on the board
A5_CH0_DQ1: U_M5a.AA2; also elsewhere on the board
A5_CH0_DQ2: U_M5a.AA3; also elsewhere on the board
A5_CH0_DQ3: U_M5a.AA4; also elsewhere on the board
A5_CH0_DQ4: U_M5a.AA5; also elsewhere on the board
A5_CH0_DQ5: U_M5a.AA6; also elsewhere on the board
A5_CH0_DQ6: U_M5a.AA7; also elsewhere on the board
A5_CH0_DQ7: U_M5a.AA8; also elsewhere on the board
A5_CH0_DQ8: U_M5a.AA9; also elsewhere on the board
A5_CH0_DQ9: U_M5a.AA10; also elsewhere on the board
A5_CH0_DQ10: U_M5a.AA11; also elsewhere on the board
A5_CH0_DQ11: U_M5a.AA12; also elsewhere on the board
A5_CH0_DQ12: U_M5a.AA13; also elsewhere on the board
A5_CH0_DQ13: U_M5a.AA14; also elsewhere on the board
A5_CH0_DQ14: U_M5a.AA15; also elsewhere on the board
A5_CH0_DQ15: U_M5a.Y1; also elsewhere on the board
A5_CH0_DQ16: U_M5a.Y2; also elsewhere on the board
A5_CH0_DQ17: U_M5a.Y3; also elsewhere on the board
A5_CH0_DQ18: U_M5a.Y4; also elsewhere on the board
A5_CH0_DQ19: U_M5a.Y5; also elsewhere on the board
A5_CH0_DQ20: U_M5a.Y6; also elsewhere on the board
A5_CH0_DQ21: U_M5a.Y7; also elsewhere on the board
A5_CH0_DQ22: U_M5a.Y8; also elsewhere on the board
A5_CH0_DQ23: U_M5a.Y9; also elsewhere on the board
A5_CH0_DQ24: U_M5a.Y10; also elsewhere on the board
A5_CH0_DQ25: U_M5a.Y11; also elsewhere on the board
A5_CH0_DQ26: U_M5a.Y12; also elsewhere on the board
A5_CH0_DQ27: U_M5a.Y13; also elsewhere on the board
A5_CH0_DQ28: U_M5a.Y14; also elsewhere on the board
A5_CH0_DQ29: U_M5a.Y15; also elsewhere on the board
A5_CH0_DQ30: U_M5a.W1; also elsewhere on the board
A5_CH0_DQ31: U_M5a.W2; also elsewhere on the board
A5_CH0_DQS0_N: U_M5a.W4; also elsewhere on the board
A5_CH0_DQS0_P: U_M5a.W3; also elsewhere on the board
A5_CH0_DQS1_N: U_M5a.W6; also elsewhere on the board
A5_CH0_DQS1_P: U_M5a.W5; also elsewhere on the board
A5_CH0_DQS2_N: U_M5a.W8; also elsewhere on the board
A5_CH0_DQS2_P: U_M5a.W7; also elsewhere on the board
A5_CH0_DQS3_N: U_M5a.W10; also elsewhere on the board
A5_CH0_DQS3_P: U_M5a.W9; also elsewhere on the board
A5_CH0_RESET: U_M5a.U5; also elsewhere on the board
A5_CH1_CA0: U_M5b.W15; also elsewhere on the board
A5_CH1_CA1: U_M5b.V1; also elsewhere on the board
A5_CH1_CA2: U_M5b.V2; also elsewhere on the board
A5_CH1_CA3: U_M5b.V3; also elsewhere on the board
A5_CH1_CA4: U_M5b.V4; also elsewhere on the board
A5_CH1_CA5: U_M5b.V5; also elsewhere on the board
A5_CH1_CA6: U_M5b.V6; also elsewhere on the board
A5_CH1_CA7: U_M5b.V7; also elsewhere on the board
A5_CH1_CA8: U_M5b.V8; also elsewhere on the board
A5_CH1_CA9: U_M5b.V9; also elsewhere on the board
A5_CH1_CA10: U_M5b.V10; also elsewhere on the board
A5_CH1_CA11: U_M5b.V11; also elsewhere on the board
A5_CH1_CA12: U_M5b.V12; also elsewhere on the board
A5_CH1_CA13: U_M5b.V13; also elsewhere on the board
A5_CH1_CK0_N: U_M5b.U2; also elsewhere on the board
A5_CH1_CK0_P: U_M5b.U1; also elsewhere on the board
A5_CH1_CK1_N: U_M5b.U4; also elsewhere on the board
A5_CH1_CK1_P: U_M5b.U3; also elsewhere on the board
A5_CH1_CS0: U_M5b.V14; also elsewhere on the board
A5_CH1_CS1: U_M5b.V15; also elsewhere on the board
A5_CH1_DMI0: U_M5b.W11; also elsewhere on the board
A5_CH1_DMI1: U_M5b.W12; also elsewhere on the board
A5_CH1_DMI2: U_M5b.W13; also elsewhere on the board
A5_CH1_DMI3: U_M5b.W14; also elsewhere on the board
A5_CH1_DQ0: U_M5b.AA1; also elsewhere on the board
A5_CH1_DQ1: U_M5b.AA2; also elsewhere on the board
A5_CH1_DQ2: U_M5b.AA3; also elsewhere on the board
A5_CH1_DQ3: U_M5b.AA4; also elsewhere on the board
A5_CH1_DQ4: U_M5b.AA5; also elsewhere on the board
A5_CH1_DQ5: U_M5b.AA6; also elsewhere on the board
A5_CH1_DQ6: U_M5b.AA7; also elsewhere on the board
A5_CH1_DQ7: U_M5b.AA8; also elsewhere on the board
A5_CH1_DQ8: U_M5b.AA9; also elsewhere on the board
A5_CH1_DQ9: U_M5b.AA10; also elsewhere on the board
A5_CH1_DQ10: U_M5b.AA11; also elsewhere on the board
A5_CH1_DQ11: U_M5b.AA12; also elsewhere on the board
A5_CH1_DQ12: U_M5b.AA13; also elsewhere on the board
A5_CH1_DQ13: U_M5b.AA14; also elsewhere on the board
A5_CH1_DQ14: U_M5b.AA15; also elsewhere on the board
A5_CH1_DQ15: U_M5b.Y1; also elsewhere on the board
A5_CH1_DQ16: U_M5b.Y2; also elsewhere on the board
A5_CH1_DQ17: U_M5b.Y3; also elsewhere on the board
A5_CH1_DQ18: U_M5b.Y4; also elsewhere on the board
A5_CH1_DQ19: U_M5b.Y5; also elsewhere on the board
A5_CH1_DQ20: U_M5b.Y6; also elsewhere on the board
A5_CH1_DQ21: U_M5b.Y7; also elsewhere on the board
A5_CH1_DQ22: U_M5b.Y8; also elsewhere on the board
A5_CH1_DQ23: U_M5b.Y9; also elsewhere on the board
A5_CH1_DQ24: U_M5b.Y10; also elsewhere on the board
A5_CH1_DQ25: U_M5b.Y11; also elsewhere on the board
A5_CH1_DQ26: U_M5b.Y12; also elsewhere on the board
A5_CH1_DQ27: U_M5b.Y13; also elsewhere on the board
A5_CH1_DQ28: U_M5b.Y14; also elsewhere on the board
A5_CH1_DQ29: U_M5b.Y15; also elsewhere on the board
A5_CH1_DQ30: U_M5b.W1; also elsewhere on the board
A5_CH1_DQ31: U_M5b.W2; also elsewhere on the board
A5_CH1_DQS0_N: U_M5b.W4; also elsewhere on the board
A5_CH1_DQS0_P: U_M5b.W3; also elsewhere on the board
A5_CH1_DQS1_N: U_M5b.W6; also elsewhere on the board
A5_CH1_DQS1_P: U_M5b.W5; also elsewhere on the board
A5_CH1_DQS2_N: U_M5b.W8; also elsewhere on the board
A5_CH1_DQS2_P: U_M5b.W7; also elsewhere on the board
A5_CH1_DQS3_N: U_M5b.W10; also elsewhere on the board
A5_CH1_DQS3_P: U_M5b.W9; also elsewhere on the board
A5_CH1_RESET: U_M5b.U5; also elsewhere on the board
A6_CH0_CA0: U_M6a.W15; also elsewhere on the board
A6_CH0_CA1: U_M6a.V1; also elsewhere on the board
A6_CH0_CA2: U_M6a.V2; also elsewhere on the board
A6_CH0_CA3: U_M6a.V3; also elsewhere on the board
A6_CH0_CA4: U_M6a.V4; also elsewhere on the board
A6_CH0_CA5: U_M6a.V5; also elsewhere on the board
A6_CH0_CA6: U_M6a.V6; also elsewhere on the board
A6_CH0_CA7: U_M6a.V7; also elsewhere on the board
A6_CH0_CA8: U_M6a.V8; also elsewhere on the board
A6_CH0_CA9: U_M6a.V9; also elsewhere on the board
A6_CH0_CA10: U_M6a.V10; also elsewhere on the board
A6_CH0_CA11: U_M6a.V11; also elsewhere on the board
A6_CH0_CA12: U_M6a.V12; also elsewhere on the board
A6_CH0_CA13: U_M6a.V13; also elsewhere on the board
A6_CH0_CK0_N: U_M6a.U2; also elsewhere on the board
A6_CH0_CK0_P: U_M6a.U1; also elsewhere on the board
A6_CH0_CK1_N: U_M6a.U4; also elsewhere on the board
A6_CH0_CK1_P: U_M6a.U3; also elsewhere on the board
A6_CH0_CS0: U_M6a.V14; also elsewhere on the board
A6_CH0_CS1: U_M6a.V15; also elsewhere on the board
A6_CH0_DMI0: U_M6a.W11; also elsewhere on the board
A6_CH0_DMI1: U_M6a.W12; also elsewhere on the board
A6_CH0_DMI2: U_M6a.W13; also elsewhere on the board
A6_CH0_DMI3: U_M6a.W14; also elsewhere on the board
A6_CH0_DQ0: U_M6a.AA1; also elsewhere on the board
A6_CH0_DQ1: U_M6a.AA2; also elsewhere on the board
A6_CH0_DQ2: U_M6a.AA3; also elsewhere on the board
A6_CH0_DQ3: U_M6a.AA4; also elsewhere on the board
A6_CH0_DQ4: U_M6a.AA5; also elsewhere on the board
A6_CH0_DQ5: U_M6a.AA6; also elsewhere on the board
A6_CH0_DQ6: U_M6a.AA7; also elsewhere on the board
A6_CH0_DQ7: U_M6a.AA8; also elsewhere on the board
A6_CH0_DQ8: U_M6a.AA9; also elsewhere on the board
A6_CH0_DQ9: U_M6a.AA10; also elsewhere on the board
A6_CH0_DQ10: U_M6a.AA11; also elsewhere on the board
A6_CH0_DQ11: U_M6a.AA12; also elsewhere on the board
A6_CH0_DQ12: U_M6a.AA13; also elsewhere on the board
A6_CH0_DQ13: U_M6a.AA14; also elsewhere on the board
A6_CH0_DQ14: U_M6a.AA15; also elsewhere on the board
A6_CH0_DQ15: U_M6a.Y1; also elsewhere on the board
A6_CH0_DQ16: U_M6a.Y2; also elsewhere on the board
A6_CH0_DQ17: U_M6a.Y3; also elsewhere on the board
A6_CH0_DQ18: U_M6a.Y4; also elsewhere on the board
A6_CH0_DQ19: U_M6a.Y5; also elsewhere on the board
A6_CH0_DQ20: U_M6a.Y6; also elsewhere on the board
A6_CH0_DQ21: U_M6a.Y7; also elsewhere on the board
A6_CH0_DQ22: U_M6a.Y8; also elsewhere on the board
A6_CH0_DQ23: U_M6a.Y9; also elsewhere on the board
A6_CH0_DQ24: U_M6a.Y10; also elsewhere on the board
A6_CH0_DQ25: U_M6a.Y11; also elsewhere on the board
A6_CH0_DQ26: U_M6a.Y12; also elsewhere on the board
A6_CH0_DQ27: U_M6a.Y13; also elsewhere on the board
A6_CH0_DQ28: U_M6a.Y14; also elsewhere on the board
A6_CH0_DQ29: U_M6a.Y15; also elsewhere on the board
A6_CH0_DQ30: U_M6a.W1; also elsewhere on the board
A6_CH0_DQ31: U_M6a.W2; also elsewhere on the board
A6_CH0_DQS0_N: U_M6a.W4; also elsewhere on the board
A6_CH0_DQS0_P: U_M6a.W3; also elsewhere on the board
A6_CH0_DQS1_N: U_M6a.W6; also elsewhere on the board
A6_CH0_DQS1_P: U_M6a.W5; also elsewhere on the board
A6_CH0_DQS2_N: U_M6a.W8; also elsewhere on the board
A6_CH0_DQS2_P: U_M6a.W7; also elsewhere on the board
A6_CH0_DQS3_N: U_M6a.W10; also elsewhere on the board
A6_CH0_DQS3_P: U_M6a.W9; also elsewhere on the board
A6_CH0_RESET: U_M6a.U5; also elsewhere on the board
A6_CH1_CA0: U_M6b.W15; also elsewhere on the board
A6_CH1_CA1: U_M6b.V1; also elsewhere on the board
A6_CH1_CA2: U_M6b.V2; also elsewhere on the board
A6_CH1_CA3: U_M6b.V3; also elsewhere on the board
A6_CH1_CA4: U_M6b.V4; also elsewhere on the board
A6_CH1_CA5: U_M6b.V5; also elsewhere on the board
A6_CH1_CA6: U_M6b.V6; also elsewhere on the board
A6_CH1_CA7: U_M6b.V7; also elsewhere on the board
A6_CH1_CA8: U_M6b.V8; also elsewhere on the board
A6_CH1_CA9: U_M6b.V9; also elsewhere on the board
A6_CH1_CA10: U_M6b.V10; also elsewhere on the board
A6_CH1_CA11: U_M6b.V11; also elsewhere on the board
A6_CH1_CA12: U_M6b.V12; also elsewhere on the board
A6_CH1_CA13: U_M6b.V13; also elsewhere on the board
A6_CH1_CK0_N: U_M6b.U2; also elsewhere on the board
A6_CH1_CK0_P: U_M6b.U1; also elsewhere on the board
A6_CH1_CK1_N: U_M6b.U4; also elsewhere on the board
A6_CH1_CK1_P: U_M6b.U3; also elsewhere on the board
A6_CH1_CS0: U_M6b.V14; also elsewhere on the board
A6_CH1_CS1: U_M6b.V15; also elsewhere on the board
A6_CH1_DMI0: U_M6b.W11; also elsewhere on the board
A6_CH1_DMI1: U_M6b.W12; also elsewhere on the board
A6_CH1_DMI2: U_M6b.W13; also elsewhere on the board
A6_CH1_DMI3: U_M6b.W14; also elsewhere on the board
A6_CH1_DQ0: U_M6b.AA1; also elsewhere on the board
A6_CH1_DQ1: U_M6b.AA2; also elsewhere on the board
A6_CH1_DQ2: U_M6b.AA3; also elsewhere on the board
A6_CH1_DQ3: U_M6b.AA4; also elsewhere on the board
A6_CH1_DQ4: U_M6b.AA5; also elsewhere on the board
A6_CH1_DQ5: U_M6b.AA6; also elsewhere on the board
A6_CH1_DQ6: U_M6b.AA7; also elsewhere on the board
A6_CH1_DQ7: U_M6b.AA8; also elsewhere on the board
A6_CH1_DQ8: U_M6b.AA9; also elsewhere on the board
A6_CH1_DQ9: U_M6b.AA10; also elsewhere on the board
A6_CH1_DQ10: U_M6b.AA11; also elsewhere on the board
A6_CH1_DQ11: U_M6b.AA12; also elsewhere on the board
A6_CH1_DQ12: U_M6b.AA13; also elsewhere on the board
A6_CH1_DQ13: U_M6b.AA14; also elsewhere on the board
A6_CH1_DQ14: U_M6b.AA15; also elsewhere on the board
A6_CH1_DQ15: U_M6b.Y1; also elsewhere on the board
A6_CH1_DQ16: U_M6b.Y2; also elsewhere on the board
A6_CH1_DQ17: U_M6b.Y3; also elsewhere on the board
A6_CH1_DQ18: U_M6b.Y4; also elsewhere on the board
A6_CH1_DQ19: U_M6b.Y5; also elsewhere on the board
A6_CH1_DQ20: U_M6b.Y6; also elsewhere on the board
A6_CH1_DQ21: U_M6b.Y7; also elsewhere on the board
A6_CH1_DQ22: U_M6b.Y8; also elsewhere on the board
A6_CH1_DQ23: U_M6b.Y9; also elsewhere on the board
A6_CH1_DQ24: U_M6b.Y10; also elsewhere on the board
A6_CH1_DQ25: U_M6b.Y11; also elsewhere on the board
A6_CH1_DQ26: U_M6b.Y12; also elsewhere on the board
A6_CH1_DQ27: U_M6b.Y13; also elsewhere on the board
A6_CH1_DQ28: U_M6b.Y14; also elsewhere on the board
A6_CH1_DQ29: U_M6b.Y15; also elsewhere on the board
A6_CH1_DQ30: U_M6b.W1; also elsewhere on the board
A6_CH1_DQ31: U_M6b.W2; also elsewhere on the board
A6_CH1_DQS0_N: U_M6b.W4; also elsewhere on the board
A6_CH1_DQS0_P: U_M6b.W3; also elsewhere on the board
A6_CH1_DQS1_N: U_M6b.W6; also elsewhere on the board
A6_CH1_DQS1_P: U_M6b.W5; also elsewhere on the board
A6_CH1_DQS2_N: U_M6b.W8; also elsewhere on the board
A6_CH1_DQS2_P: U_M6b.W7; also elsewhere on the board
A6_CH1_DQS3_N: U_M6b.W10; also elsewhere on the board
A6_CH1_DQS3_P: U_M6b.W9; also elsewhere on the board
A6_CH1_RESET: U_M6b.U5; also elsewhere on the board
A7_CH0_CA0: U_M7a.W15; also elsewhere on the board
A7_CH0_CA1: U_M7a.V1; also elsewhere on the board
A7_CH0_CA2: U_M7a.V2; also elsewhere on the board
A7_CH0_CA3: U_M7a.V3; also elsewhere on the board
A7_CH0_CA4: U_M7a.V4; also elsewhere on the board
A7_CH0_CA5: U_M7a.V5; also elsewhere on the board
A7_CH0_CA6: U_M7a.V6; also elsewhere on the board
A7_CH0_CA7: U_M7a.V7; also elsewhere on the board
A7_CH0_CA8: U_M7a.V8; also elsewhere on the board
A7_CH0_CA9: U_M7a.V9; also elsewhere on the board
A7_CH0_CA10: U_M7a.V10; also elsewhere on the board
A7_CH0_CA11: U_M7a.V11; also elsewhere on the board
A7_CH0_CA12: U_M7a.V12; also elsewhere on the board
A7_CH0_CA13: U_M7a.V13; also elsewhere on the board
A7_CH0_CK0_N: U_M7a.U2; also elsewhere on the board
A7_CH0_CK0_P: U_M7a.U1; also elsewhere on the board
A7_CH0_CK1_N: U_M7a.U4; also elsewhere on the board
A7_CH0_CK1_P: U_M7a.U3; also elsewhere on the board
A7_CH0_CS0: U_M7a.V14; also elsewhere on the board
A7_CH0_CS1: U_M7a.V15; also elsewhere on the board
A7_CH0_DMI0: U_M7a.W11; also elsewhere on the board
A7_CH0_DMI1: U_M7a.W12; also elsewhere on the board
A7_CH0_DMI2: U_M7a.W13; also elsewhere on the board
A7_CH0_DMI3: U_M7a.W14; also elsewhere on the board
A7_CH0_DQ0: U_M7a.AA1; also elsewhere on the board
A7_CH0_DQ1: U_M7a.AA2; also elsewhere on the board
A7_CH0_DQ2: U_M7a.AA3; also elsewhere on the board
A7_CH0_DQ3: U_M7a.AA4; also elsewhere on the board
A7_CH0_DQ4: U_M7a.AA5; also elsewhere on the board
A7_CH0_DQ5: U_M7a.AA6; also elsewhere on the board
A7_CH0_DQ6: U_M7a.AA7; also elsewhere on the board
A7_CH0_DQ7: U_M7a.AA8; also elsewhere on the board
A7_CH0_DQ8: U_M7a.AA9; also elsewhere on the board
A7_CH0_DQ9: U_M7a.AA10; also elsewhere on the board
A7_CH0_DQ10: U_M7a.AA11; also elsewhere on the board
A7_CH0_DQ11: U_M7a.AA12; also elsewhere on the board
A7_CH0_DQ12: U_M7a.AA13; also elsewhere on the board
A7_CH0_DQ13: U_M7a.AA14; also elsewhere on the board
A7_CH0_DQ14: U_M7a.AA15; also elsewhere on the board
A7_CH0_DQ15: U_M7a.Y1; also elsewhere on the board
A7_CH0_DQ16: U_M7a.Y2; also elsewhere on the board
A7_CH0_DQ17: U_M7a.Y3; also elsewhere on the board
A7_CH0_DQ18: U_M7a.Y4; also elsewhere on the board
A7_CH0_DQ19: U_M7a.Y5; also elsewhere on the board
A7_CH0_DQ20: U_M7a.Y6; also elsewhere on the board
A7_CH0_DQ21: U_M7a.Y7; also elsewhere on the board
A7_CH0_DQ22: U_M7a.Y8; also elsewhere on the board
A7_CH0_DQ23: U_M7a.Y9; also elsewhere on the board
A7_CH0_DQ24: U_M7a.Y10; also elsewhere on the board
A7_CH0_DQ25: U_M7a.Y11; also elsewhere on the board
A7_CH0_DQ26: U_M7a.Y12; also elsewhere on the board
A7_CH0_DQ27: U_M7a.Y13; also elsewhere on the board
A7_CH0_DQ28: U_M7a.Y14; also elsewhere on the board
A7_CH0_DQ29: U_M7a.Y15; also elsewhere on the board
A7_CH0_DQ30: U_M7a.W1; also elsewhere on the board
A7_CH0_DQ31: U_M7a.W2; also elsewhere on the board
A7_CH0_DQS0_N: U_M7a.W4; also elsewhere on the board
A7_CH0_DQS0_P: U_M7a.W3; also elsewhere on the board
A7_CH0_DQS1_N: U_M7a.W6; also elsewhere on the board
A7_CH0_DQS1_P: U_M7a.W5; also elsewhere on the board
A7_CH0_DQS2_N: U_M7a.W8; also elsewhere on the board
A7_CH0_DQS2_P: U_M7a.W7; also elsewhere on the board
A7_CH0_DQS3_N: U_M7a.W10; also elsewhere on the board
A7_CH0_DQS3_P: U_M7a.W9; also elsewhere on the board
A7_CH0_RESET: U_M7a.U5; also elsewhere on the board
A7_CH1_CA0: U_M7b.W15; also elsewhere on the board
A7_CH1_CA1: U_M7b.V1; also elsewhere on the board
A7_CH1_CA2: U_M7b.V2; also elsewhere on the board
A7_CH1_CA3: U_M7b.V3; also elsewhere on the board
A7_CH1_CA4: U_M7b.V4; also elsewhere on the board
A7_CH1_CA5: U_M7b.V5; also elsewhere on the board
A7_CH1_CA6: U_M7b.V6; also elsewhere on the board
A7_CH1_CA7: U_M7b.V7; also elsewhere on the board
A7_CH1_CA8: U_M7b.V8; also elsewhere on the board
A7_CH1_CA9: U_M7b.V9; also elsewhere on the board
A7_CH1_CA10: U_M7b.V10; also elsewhere on the board
A7_CH1_CA11: U_M7b.V11; also elsewhere on the board
A7_CH1_CA12: U_M7b.V12; also elsewhere on the board
A7_CH1_CA13: U_M7b.V13; also elsewhere on the board
A7_CH1_CK0_N: U_M7b.U2; also elsewhere on the board
A7_CH1_CK0_P: U_M7b.U1; also elsewhere on the board
A7_CH1_CK1_N: U_M7b.U4; also elsewhere on the board
A7_CH1_CK1_P: U_M7b.U3; also elsewhere on the board
A7_CH1_CS0: U_M7b.V14; also elsewhere on the board
A7_CH1_CS1: U_M7b.V15; also elsewhere on the board
A7_CH1_DMI0: U_M7b.W11; also elsewhere on the board
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