# Repository rustydc/asic (continued)

## KiCad design hw/kicad/appliance.kicad_pcb

Schematic: asics.kicad_sch

Parts:
U_A0, U_A1, U_A2, U_A3, U_A4, U_A5, U_A6, U_A7: layer_asic; FCBGA1225_35x35_P0.8
U_H0, U_H1: head_asic; FCBGA1225_35x35_P0.8

Connections (part):
A0_CH0_CA0: U_A0.B14; also elsewhere on the board
A0_CH0_CA1: U_A0.B15; also elsewhere on the board
A0_CH0_CA2: U_A0.B16; also elsewhere on the board
A0_CH0_CA3: U_A0.B17; also elsewhere on the board
A0_CH0_CA4: U_A0.B18; also elsewhere on the board
A0_CH0_CA5: U_A0.B19; also elsewhere on the board
A0_CH0_CA6: U_A0.B20; also elsewhere on the board
A0_CH0_CA7: U_A0.B21; also elsewhere on the board
A0_CH0_CA8: U_A0.B22; also elsewhere on the board
A0_CH0_CA9: U_A0.B23; also elsewhere on the board
A0_CH0_CA10: U_A0.B24; also elsewhere on the board
A0_CH0_CA11: U_A0.B25; also elsewhere on the board
A0_CH0_CA12: U_A0.B26; also elsewhere on the board
A0_CH0_CA13: U_A0.B27; also elsewhere on the board
A0_CH0_CK0_N: U_A0.B31; also elsewhere on the board
A0_CH0_CK0_P: U_A0.B30; also elsewhere on the board
A0_CH0_CK1_N: U_A0.B33; also elsewhere on the board
A0_CH0_CK1_P: U_A0.B32; also elsewhere on the board
A0_CH0_CS0: U_A0.B28; also elsewhere on the board
A0_CH0_CS1: U_A0.B29; also elsewhere on the board
A0_CH0_DMI0: U_A0.A11; also elsewhere on the board
A0_CH0_DMI1: U_A0.A23; also elsewhere on the board
A0_CH0_DMI2: U_A0.A35; also elsewhere on the board
A0_CH0_DMI3: U_A0.B12; also elsewhere on the board
A0_CH0_DQ0: U_A0.A1; also elsewhere on the board
A0_CH0_DQ1: U_A0.A2; also elsewhere on the board
A0_CH0_DQ2: U_A0.A3; also elsewhere on the board
A0_CH0_DQ3: U_A0.A4; also elsewhere on the board
A0_CH0_DQ4: U_A0.A5; also elsewhere on the board
A0_CH0_DQ5: U_A0.A6; also elsewhere on the board
A0_CH0_DQ6: U_A0.A7; also elsewhere on the board
A0_CH0_DQ7: U_A0.A8; also elsewhere on the board
A0_CH0_DQ8: U_A0.A13; also elsewhere on the board
A0_CH0_DQ9: U_A0.A14; also elsewhere on the board
A0_CH0_DQ10: U_A0.A15; also elsewhere on the board
A0_CH0_DQ11: U_A0.A16; also elsewhere on the board
A0_CH0_DQ12: U_A0.A17; also elsewhere on the board
A0_CH0_DQ13: U_A0.A18; also elsewhere on the board
A0_CH0_DQ14: U_A0.A19; also elsewhere on the board
A0_CH0_DQ15: U_A0.A20; also elsewhere on the board
A0_CH0_DQ16: U_A0.A25; also elsewhere on the board
A0_CH0_DQ17: U_A0.A26; also elsewhere on the board
A0_CH0_DQ18: U_A0.A27; also elsewhere on the board
A0_CH0_DQ19: U_A0.A28; also elsewhere on the board
A0_CH0_DQ20: U_A0.A29; also elsewhere on the board
A0_CH0_DQ21: U_A0.A30; also elsewhere on the board
A0_CH0_DQ22: U_A0.A31; also elsewhere on the board
A0_CH0_DQ23: U_A0.A32; also elsewhere on the board
A0_CH0_DQ24: U_A0.B2; also elsewhere on the board
A0_CH0_DQ25: U_A0.B3; also elsewhere on the board
A0_CH0_DQ26: U_A0.B4; also elsewhere on the board
A0_CH0_DQ27: U_A0.B5; also elsewhere on the board
A0_CH0_DQ28: U_A0.B6; also elsewhere on the board
A0_CH0_DQ29: U_A0.B7; also elsewhere on the board
A0_CH0_DQ30: U_A0.B8; also elsewhere on the board
A0_CH0_DQ31: U_A0.B9; also elsewhere on the board
A0_CH0_DQS0_N: U_A0.A10; also elsewhere on the board
A0_CH0_DQS0_P: U_A0.A9; also elsewhere on the board
A0_CH0_DQS1_N: U_A0.A22; also elsewhere on the board
A0_CH0_DQS1_P: U_A0.A21; also elsewhere on the board
A0_CH0_DQS2_N: U_A0.A34; also elsewhere on the board
A0_CH0_DQS2_P: U_A0.A33; also elsewhere on the board
A0_CH0_DQS3_N: U_A0.B11; also elsewhere on the board
A0_CH0_DQS3_P: U_A0.B10; also elsewhere on the board
A0_CH0_RESET: U_A0.B34; also elsewhere on the board
A0_CH1_CA0: U_A0.D14; also elsewhere on the board
A0_CH1_CA1: U_A0.D15; also elsewhere on the board
A0_CH1_CA2: U_A0.D16; also elsewhere on the board
A0_CH1_CA3: U_A0.D17; also elsewhere on the board
A0_CH1_CA4: U_A0.D18; also elsewhere on the board
A0_CH1_CA5: U_A0.D19; also elsewhere on the board
A0_CH1_CA6: U_A0.D20; also elsewhere on the board
A0_CH1_CA7: U_A0.D21; also elsewhere on the board
A0_CH1_CA8: U_A0.D22; also elsewhere on the board
A0_CH1_CA9: U_A0.D23; also elsewhere on the board
A0_CH1_CA10: U_A0.D24; also elsewhere on the board
A0_CH1_CA11: U_A0.D25; also elsewhere on the board
A0_CH1_CA12: U_A0.D26; also elsewhere on the board
A0_CH1_CA13: U_A0.D27; also elsewhere on the board
A0_CH1_CK0_N: U_A0.D31; also elsewhere on the board
A0_CH1_CK0_P: U_A0.D30; also elsewhere on the board
A0_CH1_CK1_N: U_A0.D33; also elsewhere on the board
A0_CH1_CK1_P: U_A0.D32; also elsewhere on the board
A0_CH1_CS0: U_A0.D28; also elsewhere on the board
A0_CH1_CS1: U_A0.D29; also elsewhere on the board
A0_CH1_DMI0: U_A0.C11; also elsewhere on the board
A0_CH1_DMI1: U_A0.C23; also elsewhere on the board
A0_CH1_DMI2: U_A0.C35; also elsewhere on the board
A0_CH1_DMI3: U_A0.D12; also elsewhere on the board
A0_CH1_DQ0: U_A0.C1; also elsewhere on the board
A0_CH1_DQ1: U_A0.C2; also elsewhere on the board
A0_CH1_DQ2: U_A0.C3; also elsewhere on the board
A0_CH1_DQ3: U_A0.C4; also elsewhere on the board
A0_CH1_DQ4: U_A0.C5; also elsewhere on the board
A0_CH1_DQ5: U_A0.C6; also elsewhere on the board
A0_CH1_DQ6: U_A0.C7; also elsewhere on the board
A0_CH1_DQ7: U_A0.C8; also elsewhere on the board
A0_CH1_DQ8: U_A0.C13; also elsewhere on the board
A0_CH1_DQ9: U_A0.C14; also elsewhere on the board
A0_CH1_DQ10: U_A0.C15; also elsewhere on the board
A0_CH1_DQ11: U_A0.C16; also elsewhere on the board
A0_CH1_DQ12: U_A0.C17; also elsewhere on the board
A0_CH1_DQ13: U_A0.C18; also elsewhere on the board
A0_CH1_DQ14: U_A0.C19; also elsewhere on the board
A0_CH1_DQ15: U_A0.C20; also elsewhere on the board
A0_CH1_DQ16: U_A0.C25; also elsewhere on the board
A0_CH1_DQ17: U_A0.C26; also elsewhere on the board
A0_CH1_DQ18: U_A0.C27; also elsewhere on the board
A0_CH1_DQ19: U_A0.C28; also elsewhere on the board
A0_CH1_DQ20: U_A0.C29; also elsewhere on the board
A0_CH1_DQ21: U_A0.C30; also elsewhere on the board
A0_CH1_DQ22: U_A0.C31; also elsewhere on the board
A0_CH1_DQ23: U_A0.C32; also elsewhere on the board
A0_CH1_DQ24: U_A0.D2; also elsewhere on the board
A0_CH1_DQ25: U_A0.D3; also elsewhere on the board
A0_CH1_DQ26: U_A0.D4; also elsewhere on the board
A0_CH1_DQ27: U_A0.D5; also elsewhere on the board
A0_CH1_DQ28: U_A0.D6; also elsewhere on the board
A0_CH1_DQ29: U_A0.D7; also elsewhere on the board
A0_CH1_DQ30: U_A0.D8; also elsewhere on the board
A0_CH1_DQ31: U_A0.D9; also elsewhere on the board
A0_CH1_DQS0_N: U_A0.C10; also elsewhere on the board
A0_CH1_DQS0_P: U_A0.C9; also elsewhere on the board
A0_CH1_DQS1_N: U_A0.C22; also elsewhere on the board
A0_CH1_DQS1_P: U_A0.C21; also elsewhere on the board
A0_CH1_DQS2_N: U_A0.C34; also elsewhere on the board
A0_CH1_DQS2_P: U_A0.C33; also elsewhere on the board
A0_CH1_DQS3_N: U_A0.D11; also elsewhere on the board
A0_CH1_DQS3_P: U_A0.D10; also elsewhere on the board
A0_CH1_RESET: U_A0.D34; also elsewhere on the board
A1_CH0_CA0: U_A1.B14; also elsewhere on the board
A1_CH0_CA1: U_A1.B15; also elsewhere on the board
A1_CH0_CA2: U_A1.B16; also elsewhere on the board
A1_CH0_CA3: U_A1.B17; also elsewhere on the board
A1_CH0_CA4: U_A1.B18; also elsewhere on the board
A1_CH0_CA5: U_A1.B19; also elsewhere on the board
A1_CH0_CA6: U_A1.B20; also elsewhere on the board
A1_CH0_CA7: U_A1.B21; also elsewhere on the board
A1_CH0_CA8: U_A1.B22; also elsewhere on the board
A1_CH0_CA9: U_A1.B23; also elsewhere on the board
A1_CH0_CA10: U_A1.B24; also elsewhere on the board
A1_CH0_CA11: U_A1.B25; also elsewhere on the board
A1_CH0_CA12: U_A1.B26; also elsewhere on the board
A1_CH0_CA13: U_A1.B27; also elsewhere on the board
A1_CH0_CK0_N: U_A1.B31; also elsewhere on the board
A1_CH0_CK0_P: U_A1.B30; also elsewhere on the board
A1_CH0_CK1_N: U_A1.B33; also elsewhere on the board
A1_CH0_CK1_P: U_A1.B32; also elsewhere on the board
A1_CH0_CS0: U_A1.B28; also elsewhere on the board
A1_CH0_CS1: U_A1.B29; also elsewhere on the board
A1_CH0_DMI0: U_A1.A11; also elsewhere on the board
A1_CH0_DMI1: U_A1.A23; also elsewhere on the board
A1_CH0_DMI2: U_A1.A35; also elsewhere on the board
A1_CH0_DMI3: U_A1.B12; also elsewhere on the board
A1_CH0_DQ0: U_A1.A1; also elsewhere on the board
A1_CH0_DQ1: U_A1.A2; also elsewhere on the board
A1_CH0_DQ2: U_A1.A3; also elsewhere on the board
A1_CH0_DQ3: U_A1.A4; also elsewhere on the board
A1_CH0_DQ4: U_A1.A5; also elsewhere on the board
A1_CH0_DQ5: U_A1.A6; also elsewhere on the board
A1_CH0_DQ6: U_A1.A7; also elsewhere on the board
A1_CH0_DQ7: U_A1.A8; also elsewhere on the board
A1_CH0_DQ8: U_A1.A13; also elsewhere on the board
A1_CH0_DQ9: U_A1.A14; also elsewhere on the board
A1_CH0_DQ10: U_A1.A15; also elsewhere on the board
A1_CH0_DQ11: U_A1.A16; also elsewhere on the board
A1_CH0_DQ12: U_A1.A17; also elsewhere on the board
A1_CH0_DQ13: U_A1.A18; also elsewhere on the board
A1_CH0_DQ14: U_A1.A19; also elsewhere on the board
A1_CH0_DQ15: U_A1.A20; also elsewhere on the board
A1_CH0_DQ16: U_A1.A25; also elsewhere on the board
A1_CH0_DQ17: U_A1.A26; also elsewhere on the board
A1_CH0_DQ18: U_A1.A27; also elsewhere on the board
A1_CH0_DQ19: U_A1.A28; also elsewhere on the board
A1_CH0_DQ20: U_A1.A29; also elsewhere on the board
A1_CH0_DQ21: U_A1.A30; also elsewhere on the board
A1_CH0_DQ22: U_A1.A31; also elsewhere on the board
A1_CH0_DQ23: U_A1.A32; also elsewhere on the board
A1_CH0_DQ24: U_A1.B2; also elsewhere on the board
A1_CH0_DQ25: U_A1.B3; also elsewhere on the board
A1_CH0_DQ26: U_A1.B4; also elsewhere on the board
A1_CH0_DQ27: U_A1.B5; also elsewhere on the board
A1_CH0_DQ28: U_A1.B6; also elsewhere on the board
A1_CH0_DQ29: U_A1.B7; also elsewhere on the board
A1_CH0_DQ30: U_A1.B8; also elsewhere on the board
A1_CH0_DQ31: U_A1.B9; also elsewhere on the board
A1_CH0_DQS0_N: U_A1.A10; also elsewhere on the board
A1_CH0_DQS0_P: U_A1.A9; also elsewhere on the board
A1_CH0_DQS1_N: U_A1.A22; also elsewhere on the board
A1_CH0_DQS1_P: U_A1.A21; also elsewhere on the board
A1_CH0_DQS2_N: U_A1.A34; also elsewhere on the board
A1_CH0_DQS2_P: U_A1.A33; also elsewhere on the board
A1_CH0_DQS3_N: U_A1.B11; also elsewhere on the board
A1_CH0_DQS3_P: U_A1.B10; also elsewhere on the board
A1_CH0_RESET: U_A1.B34; also elsewhere on the board
A1_CH1_CA0: U_A1.D14; also elsewhere on the board
A1_CH1_CA1: U_A1.D15; also elsewhere on the board
A1_CH1_CA2: U_A1.D16; also elsewhere on the board
A1_CH1_CA3: U_A1.D17; also elsewhere on the board
A1_CH1_CA4: U_A1.D18; also elsewhere on the board
A1_CH1_CA5: U_A1.D19; also elsewhere on the board
A1_CH1_CA6: U_A1.D20; also elsewhere on the board
A1_CH1_CA7: U_A1.D21; also elsewhere on the board
A1_CH1_CA8: U_A1.D22; also elsewhere on the board
A1_CH1_CA9: U_A1.D23; also elsewhere on the board
A1_CH1_CA10: U_A1.D24; also elsewhere on the board
A1_CH1_CA11: U_A1.D25; also elsewhere on the board
A1_CH1_CA12: U_A1.D26; also elsewhere on the board
A1_CH1_CA13: U_A1.D27; also elsewhere on the board
A1_CH1_CK0_N: U_A1.D31; also elsewhere on the board
A1_CH1_CK0_P: U_A1.D30; also elsewhere on the board
A1_CH1_CK1_N: U_A1.D33; also elsewhere on the board
A1_CH1_CK1_P: U_A1.D32; also elsewhere on the board
A1_CH1_CS0: U_A1.D28; also elsewhere on the board
A1_CH1_CS1: U_A1.D29; also elsewhere on the board
A1_CH1_DMI0: U_A1.C11; also elsewhere on the board
A1_CH1_DMI1: U_A1.C23; also elsewhere on the board
A1_CH1_DMI2: U_A1.C35; also elsewhere on the board
A1_CH1_DMI3: U_A1.D12; also elsewhere on the board
A1_CH1_DQ0: U_A1.C1; also elsewhere on the board
A1_CH1_DQ1: U_A1.C2; also elsewhere on the board
A1_CH1_DQ2: U_A1.C3; also elsewhere on the board
A1_CH1_DQ3: U_A1.C4; also elsewhere on the board
A1_CH1_DQ4: U_A1.C5; also elsewhere on the board
A1_CH1_DQ5: U_A1.C6; also elsewhere on the board
A1_CH1_DQ6: U_A1.C7; also elsewhere on the board
A1_CH1_DQ7: U_A1.C8; also elsewhere on the board
A1_CH1_DQ8: U_A1.C13; also elsewhere on the board
A1_CH1_DQ9: U_A1.C14; also elsewhere on the board
A1_CH1_DQ10: U_A1.C15; also elsewhere on the board
A1_CH1_DQ11: U_A1.C16; also elsewhere on the board
A1_CH1_DQ12: U_A1.C17; also elsewhere on the board
A1_CH1_DQ13: U_A1.C18; also elsewhere on the board
A1_CH1_DQ14: U_A1.C19; also elsewhere on the board
A1_CH1_DQ15: U_A1.C20; also elsewhere on the board
A1_CH1_DQ16: U_A1.C25; also elsewhere on the board
A1_CH1_DQ17: U_A1.C26; also elsewhere on the board
A1_CH1_DQ18: U_A1.C27; also elsewhere on the board
A1_CH1_DQ19: U_A1.C28; also elsewhere on the board
A1_CH1_DQ20: U_A1.C29; also elsewhere on the board
A1_CH1_DQ21: U_A1.C30; also elsewhere on the board
A1_CH1_DQ22: U_A1.C31; also elsewhere on the board
A1_CH1_DQ23: U_A1.C32; also elsewhere on the board
A1_CH1_DQ24: U_A1.D2; also elsewhere on the board
A1_CH1_DQ25: U_A1.D3; also elsewhere on the board
A1_CH1_DQ26: U_A1.D4; also elsewhere on the board
A1_CH1_DQ27: U_A1.D5; also elsewhere on the board
A1_CH1_DQ28: U_A1.D6; also elsewhere on the board
A1_CH1_DQ29: U_A1.D7; also elsewhere on the board
A1_CH1_DQ30: U_A1.D8; also elsewhere on the board
A1_CH1_DQ31: U_A1.D9; also elsewhere on the board
A1_CH1_DQS0_N: U_A1.C10; also elsewhere on the board
A1_CH1_DQS0_P: U_A1.C9; also elsewhere on the board
A1_CH1_DQS1_N: U_A1.C22; also elsewhere on the board
A1_CH1_DQS1_P: U_A1.C21; also elsewhere on the board
A1_CH1_DQS2_N: U_A1.C34; also elsewhere on the board
A1_CH1_DQS2_P: U_A1.C33; also elsewhere on the board
A1_CH1_DQS3_N: U_A1.D11; also elsewhere on the board
A1_CH1_DQS3_P: U_A1.D10; also elsewhere on the board
A1_CH1_RESET: U_A1.D34; also elsewhere on the board
A2_CH0_CA0: U_A2.B14; also elsewhere on the board
A2_CH0_CA1: U_A2.B15; also elsewhere on the board
A2_CH0_CA2: U_A2.B16; also elsewhere on the board
A2_CH0_CA3: U_A2.B17; also elsewhere on the board
A2_CH0_CA4: U_A2.B18; also elsewhere on the board
A2_CH0_CA5: U_A2.B19; also elsewhere on the board
A2_CH0_CA6: U_A2.B20; also elsewhere on the board
A2_CH0_CA7: U_A2.B21; also elsewhere on the board
A2_CH0_CA8: U_A2.B22; also elsewhere on the board
A2_CH0_CA9: U_A2.B23; also elsewhere on the board
A2_CH0_CA10: U_A2.B24; also elsewhere on the board
A2_CH0_CA11: U_A2.B25; also elsewhere on the board
A2_CH0_CA12: U_A2.B26; also elsewhere on the board
A2_CH0_CA13: U_A2.B27; also elsewhere on the board
A2_CH0_CK0_N: U_A2.B31; also elsewhere on the board
A2_CH0_CK0_P: U_A2.B30; also elsewhere on the board
A2_CH0_CK1_N: U_A2.B33; also elsewhere on the board
A2_CH0_CK1_P: U_A2.B32; also elsewhere on the board
A2_CH0_CS0: U_A2.B28; also elsewhere on the board
A2_CH0_CS1: U_A2.B29; also elsewhere on the board
A2_CH0_DMI0: U_A2.A11; also elsewhere on the board
A2_CH0_DMI1: U_A2.A23; also elsewhere on the board
A2_CH0_DMI2: U_A2.A35; also elsewhere on the board
A2_CH0_DMI3: U_A2.B12; also elsewhere on the board
A2_CH0_DQ0: U_A2.A1; also elsewhere on the board
A2_CH0_DQ1: U_A2.A2; also elsewhere on the board
A2_CH0_DQ2: U_A2.A3; also elsewhere on the board
A2_CH0_DQ3: U_A2.A4; also elsewhere on the board
A2_CH0_DQ4: U_A2.A5; also elsewhere on the board
A2_CH0_DQ5: U_A2.A6; also elsewhere on the board
A2_CH0_DQ6: U_A2.A7; also elsewhere on the board
A2_CH0_DQ7: U_A2.A8; also elsewhere on the board
A2_CH0_DQ8: U_A2.A13; also elsewhere on the board
A2_CH0_DQ9: U_A2.A14; also elsewhere on the board
A2_CH0_DQ10: U_A2.A15; also elsewhere on the board
A2_CH0_DQ11: U_A2.A16; also elsewhere on the board
A2_CH0_DQ12: U_A2.A17; also elsewhere on the board
A2_CH0_DQ13: U_A2.A18; also elsewhere on the board
A2_CH0_DQ14: U_A2.A19; also elsewhere on the board
A2_CH0_DQ15: U_A2.A20; also elsewhere on the board
A2_CH0_DQ16: U_A2.A25; also elsewhere on the board
A2_CH0_DQ17: U_A2.A26; also elsewhere on the board
A2_CH0_DQ18: U_A2.A27; also elsewhere on the board
A2_CH0_DQ19: U_A2.A28; also elsewhere on the board
A2_CH0_DQ20: U_A2.A29; also elsewhere on the board
A2_CH0_DQ21: U_A2.A30; also elsewhere on the board
A2_CH0_DQ22: U_A2.A31; also elsewhere on the board
A2_CH0_DQ23: U_A2.A32; also elsewhere on the board
A2_CH0_DQ24: U_A2.B2; also elsewhere on the board
A2_CH0_DQ25: U_A2.B3; also elsewhere on the board
A2_CH0_DQ26: U_A2.B4; also elsewhere on the board
A2_CH0_DQ27: U_A2.B5; also elsewhere on the board
A2_CH0_DQ28: U_A2.B6; also elsewhere on the board
A2_CH0_DQ29: U_A2.B7; also elsewhere on the board
A2_CH0_DQ30: U_A2.B8; also elsewhere on the board
A2_CH0_DQ31: U_A2.B9; also elsewhere on the board
A2_CH0_DQS0_N: U_A2.A10; also elsewhere on the board
A2_CH0_DQS0_P: U_A2.A9; also elsewhere on the board
A2_CH0_DQS1_N: U_A2.A22; also elsewhere on the board
A2_CH0_DQS1_P: U_A2.A21; also elsewhere on the board
A2_CH0_DQS2_N: U_A2.A34; also elsewhere on the board
A2_CH0_DQS2_P: U_A2.A33; also elsewhere on the board
A2_CH0_DQS3_N: U_A2.B11; also elsewhere on the board
A2_CH0_DQS3_P: U_A2.B10; also elsewhere on the board
A2_CH0_RESET: U_A2.B34; also elsewhere on the board
A2_CH1_CA0: U_A2.D14; also elsewhere on the board
A2_CH1_CA1: U_A2.D15; also elsewhere on the board
A2_CH1_CA2: U_A2.D16; also elsewhere on the board
A2_CH1_CA3: U_A2.D17; also elsewhere on the board
A2_CH1_CA4: U_A2.D18; also elsewhere on the board
A2_CH1_CA5: U_A2.D19; also elsewhere on the board
A2_CH1_CA6: U_A2.D20; also elsewhere on the board
A2_CH1_CA7: U_A2.D21; also elsewhere on the board
A2_CH1_CA8: U_A2.D22; also elsewhere on the board
A2_CH1_CA9: U_A2.D23; also elsewhere on the board
A2_CH1_CA10: U_A2.D24; also elsewhere on the board
A2_CH1_CA11: U_A2.D25; also elsewhere on the board
A2_CH1_CA12: U_A2.D26; also elsewhere on the board
A2_CH1_CA13: U_A2.D27; also elsewhere on the board
A2_CH1_CK0_N: U_A2.D31; also elsewhere on the board
A2_CH1_CK0_P: U_A2.D30; also elsewhere on the board
A2_CH1_CK1_N: U_A2.D33; also elsewhere on the board
A2_CH1_CK1_P: U_A2.D32; also elsewhere on the board
A2_CH1_CS0: U_A2.D28; also elsewhere on the board
A2_CH1_CS1: U_A2.D29; also elsewhere on the board
A2_CH1_DMI0: U_A2.C11; also elsewhere on the board
A2_CH1_DMI1: U_A2.C23; also elsewhere on the board
A2_CH1_DMI2: U_A2.C35; also elsewhere on the board
A2_CH1_DMI3: U_A2.D12; also elsewhere on the board
A2_CH1_DQ0: U_A2.C1; also elsewhere on the board
A2_CH1_DQ1: U_A2.C2; also elsewhere on the board
A2_CH1_DQ2: U_A2.C3; also elsewhere on the board
A2_CH1_DQ3: U_A2.C4; also elsewhere on the board
A2_CH1_DQ4: U_A2.C5; also elsewhere on the board
A2_CH1_DQ5: U_A2.C6; also elsewhere on the board
A2_CH1_DQ6: U_A2.C7; also elsewhere on the board
A2_CH1_DQ7: U_A2.C8; also elsewhere on the board
A2_CH1_DQ8: U_A2.C13; also elsewhere on the board
A2_CH1_DQ9: U_A2.C14; also elsewhere on the board
A2_CH1_DQ10: U_A2.C15; also elsewhere on the board
A2_CH1_DQ11: U_A2.C16; also elsewhere on the board
A2_CH1_DQ12: U_A2.C17; also elsewhere on the board
A2_CH1_DQ13: U_A2.C18; also elsewhere on the board
A2_CH1_DQ14: U_A2.C19; also elsewhere on the board
A2_CH1_DQ15: U_A2.C20; also elsewhere on the board
A2_CH1_DQ16: U_A2.C25; also elsewhere on the board
A2_CH1_DQ17: U_A2.C26; also elsewhere on the board
A2_CH1_DQ18: U_A2.C27; also elsewhere on the board
A2_CH1_DQ19: U_A2.C28; also elsewhere on the board
A2_CH1_DQ20: U_A2.C29; also elsewhere on the board
A2_CH1_DQ21: U_A2.C30; also elsewhere on the board
A2_CH1_DQ22: U_A2.C31; also elsewhere on the board
A2_CH1_DQ23: U_A2.C32; also elsewhere on the board
A2_CH1_DQ24: U_A2.D2; also elsewhere on the board
A2_CH1_DQ25: U_A2.D3; also elsewhere on the board
A2_CH1_DQ26: U_A2.D4; also elsewhere on the board
A2_CH1_DQ27: U_A2.D5; also elsewhere on the board
A2_CH1_DQ28: U_A2.D6; also elsewhere on the board
A2_CH1_DQ29: U_A2.D7; also elsewhere on the board
A2_CH1_DQ30: U_A2.D8; also elsewhere on the board
A2_CH1_DQ31: U_A2.D9; also elsewhere on the board
A2_CH1_DQS0_N: U_A2.C10; also elsewhere on the board
A2_CH1_DQS0_P: U_A2.C9; also elsewhere on the board
A2_CH1_DQS1_N: U_A2.C22; also elsewhere on the board
A2_CH1_DQS1_P: U_A2.C21; also elsewhere on the board
A2_CH1_DQS2_N: U_A2.C34; also elsewhere on the board
A2_CH1_DQS2_P: U_A2.C33; also elsewhere on the board
A2_CH1_DQS3_N: U_A2.D11; also elsewhere on the board
A2_CH1_DQS3_P: U_A2.D10; also elsewhere on the board
A2_CH1_RESET: U_A2.D34; also elsewhere on the board
A3_CH0_CA0: U_A3.B14; also elsewhere on the board
A3_CH0_CA1: U_A3.B15; also elsewhere on the board
A3_CH0_CA2: U_A3.B16; also elsewhere on the board
A3_CH0_CA3: U_A3.B17; also elsewhere on the board
A3_CH0_CA4: U_A3.B18; also elsewhere on the board
A3_CH0_CA5: U_A3.B19; also elsewhere on the board
A3_CH0_CA6: U_A3.B20; also elsewhere on the board
A3_CH0_CA7: U_A3.B21; also elsewhere on the board
A3_CH0_CA8: U_A3.B22; also elsewhere on the board
A3_CH0_CA9: U_A3.B23; also elsewhere on the board
A3_CH0_CA10: U_A3.B24; also elsewhere on the board
A3_CH0_CA11: U_A3.B25; also elsewhere on the board
A3_CH0_CA12: U_A3.B26; also elsewhere on the board
A3_CH0_CA13: U_A3.B27; also elsewhere on the board
A3_CH0_CK0_N: U_A3.B31; also elsewhere on the board
A3_CH0_CK0_P: U_A3.B30; also elsewhere on the board
A3_CH0_CK1_N: U_A3.B33; also elsewhere on the board
A3_CH0_CK1_P: U_A3.B32; also elsewhere on the board
A3_CH0_CS0: U_A3.B28; also elsewhere on the board
A3_CH0_CS1: U_A3.B29; also elsewhere on the board
A3_CH0_DMI0: U_A3.A11; also elsewhere on the board
A3_CH0_DMI1: U_A3.A23; also elsewhere on the board
A3_CH0_DMI2: U_A3.A35; also elsewhere on the board
A3_CH0_DMI3: U_A3.B12; also elsewhere on the board
A3_CH0_DQ0: U_A3.A1; also elsewhere on the board
A3_CH0_DQ1: U_A3.A2; also elsewhere on the board
A3_CH0_DQ2: U_A3.A3; also elsewhere on the board
A3_CH0_DQ3: U_A3.A4; also elsewhere on the board
A3_CH0_DQ4: U_A3.A5; also elsewhere on the board
A3_CH0_DQ5: U_A3.A6; also elsewhere on the board
A3_CH0_DQ6: U_A3.A7; also elsewhere on the board
A3_CH0_DQ7: U_A3.A8; also elsewhere on the board
A3_CH0_DQ8: U_A3.A13; also elsewhere on the board
A3_CH0_DQ9: U_A3.A14; also elsewhere on the board
A3_CH0_DQ10: U_A3.A15; also elsewhere on the board
A3_CH0_DQ11: U_A3.A16; also elsewhere on the board
A3_CH0_DQ12: U_A3.A17; also elsewhere on the board
A3_CH0_DQ13: U_A3.A18; also elsewhere on the board
A3_CH0_DQ14: U_A3.A19; also elsewhere on the board
A3_CH0_DQ15: U_A3.A20; also elsewhere on the board
A3_CH0_DQ16: U_A3.A25; also elsewhere on the board
A3_CH0_DQ17: U_A3.A26; also elsewhere on the board
A3_CH0_DQ18: U_A3.A27; also elsewhere on the board
A3_CH0_DQ19: U_A3.A28; also elsewhere on the board
A3_CH0_DQ20: U_A3.A29; also elsewhere on the board
A3_CH0_DQ21: U_A3.A30; also elsewhere on the board
A3_CH0_DQ22: U_A3.A31; also elsewhere on the board
A3_CH0_DQ23: U_A3.A32; also elsewhere on the board
A3_CH0_DQ24: U_A3.B2; also elsewhere on the board
A3_CH0_DQ25: U_A3.B3; also elsewhere on the board
A3_CH0_DQ26: U_A3.B4; also elsewhere on the board
A3_CH0_DQ27: U_A3.B5; also elsewhere on the board
A3_CH0_DQ28: U_A3.B6; also elsewhere on the board
A3_CH0_DQ29: U_A3.B7; also elsewhere on the board
A3_CH0_DQ30: U_A3.B8; also elsewhere on the board
A3_CH0_DQ31: U_A3.B9; also elsewhere on the board
A3_CH0_DQS0_N: U_A3.A10; also elsewhere on the board
A3_CH0_DQS0_P: U_A3.A9; also elsewhere on the board
A3_CH0_DQS1_N: U_A3.A22; also elsewhere on the board
A3_CH0_DQS1_P: U_A3.A21; also elsewhere on the board
A3_CH0_DQS2_N: U_A3.A34; also elsewhere on the board
A3_CH0_DQS2_P: U_A3.A33; also elsewhere on the board
A3_CH0_DQS3_N: U_A3.B11; also elsewhere on the board
A3_CH0_DQS3_P: U_A3.B10; also elsewhere on the board
A3_CH0_RESET: U_A3.B34; also elsewhere on the board
A3_CH1_CA0: U_A3.D14; also elsewhere on the board
A3_CH1_CA1: U_A3.D15; also elsewhere on the board
A3_CH1_CA2: U_A3.D16; also elsewhere on the board
A3_CH1_CA3: U_A3.D17; also elsewhere on the board
A3_CH1_CA4: U_A3.D18; also elsewhere on the board
A3_CH1_CA5: U_A3.D19; also elsewhere on the board
A3_CH1_CA6: U_A3.D20; also elsewhere on the board
A3_CH1_CA7: U_A3.D21; also elsewhere on the board
A3_CH1_CA8: U_A3.D22; also elsewhere on the board
A3_CH1_CA9: U_A3.D23; also elsewhere on the board
A3_CH1_CA10: U_A3.D24; also elsewhere on the board
A3_CH1_CA11: U_A3.D25; also elsewhere on the board
A3_CH1_CA12: U_A3.D26; also elsewhere on the board
A3_CH1_CA13: U_A3.D27; also elsewhere on the board
A3_CH1_CK0_N: U_A3.D31; also elsewhere on the board
A3_CH1_CK0_P: U_A3.D30; also elsewhere on the board
A3_CH1_CK1_N: U_A3.D33; also elsewhere on the board
A3_CH1_CK1_P: U_A3.D32; also elsewhere on the board
A3_CH1_CS0: U_A3.D28; also elsewhere on the board
A3_CH1_CS1: U_A3.D29; also elsewhere on the board
A3_CH1_DMI0: U_A3.C11; also elsewhere on the board
A3_CH1_DMI1: U_A3.C23; also elsewhere on the board
A3_CH1_DMI2: U_A3.C35; also elsewhere on the board
A3_CH1_DMI3: U_A3.D12; also elsewhere on the board
A3_CH1_DQ0: U_A3.C1; also elsewhere on the board
A3_CH1_DQ1: U_A3.C2; also elsewhere on the board
A3_CH1_DQ2: U_A3.C3; also elsewhere on the board
A3_CH1_DQ3: U_A3.C4; also elsewhere on the board
A3_CH1_DQ4: U_A3.C5; also elsewhere on the board
A3_CH1_DQ5: U_A3.C6; also elsewhere on the board
A3_CH1_DQ6: U_A3.C7; also elsewhere on the board
A3_CH1_DQ7: U_A3.C8; also elsewhere on the board
A3_CH1_DQ8: U_A3.C13; also elsewhere on the board
A3_CH1_DQ9: U_A3.C14; also elsewhere on the board
A3_CH1_DQ10: U_A3.C15; also elsewhere on the board
A3_CH1_DQ11: U_A3.C16; also elsewhere on the board
A3_CH1_DQ12: U_A3.C17; also elsewhere on the board
A3_CH1_DQ13: U_A3.C18; also elsewhere on the board
A3_CH1_DQ14: U_A3.C19; also elsewhere on the board
A3_CH1_DQ15: U_A3.C20; also elsewhere on the board
A3_CH1_DQ16: U_A3.C25; also elsewhere on the board
A3_CH1_DQ17: U_A3.C26; also elsewhere on the board
A3_CH1_DQ18: U_A3.C27; also elsewhere on the board
A3_CH1_DQ19: U_A3.C28; also elsewhere on the board
A3_CH1_DQ20: U_A3.C29; also elsewhere on the board
A3_CH1_DQ21: U_A3.C30; also elsewhere on the board
A3_CH1_DQ22: U_A3.C31; also elsewhere on the board
A3_CH1_DQ23: U_A3.C32; also elsewhere on the board
A3_CH1_DQ24: U_A3.D2; also elsewhere on the board
A3_CH1_DQ25: U_A3.D3; also elsewhere on the board
A3_CH1_DQ26: U_A3.D4; also elsewhere on the board
A3_CH1_DQ27: U_A3.D5; also elsewhere on the board
A3_CH1_DQ28: U_A3.D6; also elsewhere on the board
A3_CH1_DQ29: U_A3.D7; also elsewhere on the board
A3_CH1_DQ30: U_A3.D8; also elsewhere on the board
A3_CH1_DQ31: U_A3.D9; also elsewhere on the board
A3_CH1_DQS0_N: U_A3.C10; also elsewhere on the board
A3_CH1_DQS0_P: U_A3.C9; also elsewhere on the board
A3_CH1_DQS1_N: U_A3.C22; also elsewhere on the board
A3_CH1_DQS1_P: U_A3.C21; also elsewhere on the board
A3_CH1_DQS2_N: U_A3.C34; also elsewhere on the board
A3_CH1_DQS2_P: U_A3.C33; also elsewhere on the board
A3_CH1_DQS3_N: U_A3.D11; also elsewhere on the board
A3_CH1_DQS3_P: U_A3.D10; also elsewhere on the board
A3_CH1_RESET: U_A3.D34; also elsewhere on the board
A4_CH0_CA0: U_A4.B14; also elsewhere on the board
A4_CH0_CA1: U_A4.B15; also elsewhere on the board
A4_CH0_CA2: U_A4.B16; also elsewhere on the board
A4_CH0_CA3: U_A4.B17; also elsewhere on the board
A4_CH0_CA4: U_A4.B18; also elsewhere on the board
A4_CH0_CA5: U_A4.B19; also elsewhere on the board
A4_CH0_CA6: U_A4.B20; also elsewhere on the board
A4_CH0_CA7: U_A4.B21; also elsewhere on the board
A4_CH0_CA8: U_A4.B22; also elsewhere on the board
A4_CH0_CA9: U_A4.B23; also elsewhere on the board
A4_CH0_CA10: U_A4.B24; also elsewhere on the board
A4_CH0_CA11: U_A4.B25; also elsewhere on the board
A4_CH0_CA12: U_A4.B26; also elsewhere on the board
A4_CH0_CA13: U_A4.B27; also elsewhere on the board
A4_CH0_CK0_N: U_A4.B31; also elsewhere on the board
A4_CH0_CK0_P: U_A4.B30; also elsewhere on the board
A4_CH0_CK1_N: U_A4.B33; also elsewhere on the board
A4_CH0_CK1_P: U_A4.B32; also elsewhere on the board
A4_CH0_CS0: U_A4.B28; also elsewhere on the board
A4_CH0_CS1: U_A4.B29; also elsewhere on the board
A4_CH0_DMI0: U_A4.A11; also elsewhere on the board
A4_CH0_DMI1: U_A4.A23; also elsewhere on the board
A4_CH0_DMI2: U_A4.A35; also elsewhere on the board
A4_CH0_DMI3: U_A4.B12; also elsewhere on the board
A4_CH0_DQ0: U_A4.A1; also elsewhere on the board
A4_CH0_DQ1: U_A4.A2; also elsewhere on the board
A4_CH0_DQ2: U_A4.A3; also elsewhere on the board
A4_CH0_DQ3: U_A4.A4; also elsewhere on the board
A4_CH0_DQ4: U_A4.A5; also elsewhere on the board
A4_CH0_DQ5: U_A4.A6; also elsewhere on the board
A4_CH0_DQ6: U_A4.A7; also elsewhere on the board
A4_CH0_DQ7: U_A4.A8; also elsewhere on the board
A4_CH0_DQ8: U_A4.A13; also elsewhere on the board
A4_CH0_DQ9: U_A4.A14; also elsewhere on the board
A4_CH0_DQ10: U_A4.A15; also elsewhere on the board
A4_CH0_DQ11: U_A4.A16; also elsewhere on the board
A4_CH0_DQ12: U_A4.A17; also elsewhere on the board
A4_CH0_DQ13: U_A4.A18; also elsewhere on the board
A4_CH0_DQ14: U_A4.A19; also elsewhere on the board
A4_CH0_DQ15: U_A4.A20; also elsewhere on the board
A4_CH0_DQ16: U_A4.A25; also elsewhere on the board
A4_CH0_DQ17: U_A4.A26; also elsewhere on the board
A4_CH0_DQ18: U_A4.A27; also elsewhere on the board
A4_CH0_DQ19: U_A4.A28; also elsewhere on the board
A4_CH0_DQ20: U_A4.A29; also elsewhere on the board
A4_CH0_DQ21: U_A4.A30; also elsewhere on the board
A4_CH0_DQ22: U_A4.A31; also elsewhere on the board
A4_CH0_DQ23: U_A4.A32; also elsewhere on the board
A4_CH0_DQ24: U_A4.B2; also elsewhere on the board
A4_CH0_DQ25: U_A4.B3; also elsewhere on the board
A4_CH0_DQ26: U_A4.B4; also elsewhere on the board
A4_CH0_DQ27: U_A4.B5; also elsewhere on the board
A4_CH0_DQ28: U_A4.B6; also elsewhere on the board
A4_CH0_DQ29: U_A4.B7; also elsewhere on the board
A4_CH0_DQ30: U_A4.B8; also elsewhere on the board
A4_CH0_DQ31: U_A4.B9; also elsewhere on the board
A4_CH0_DQS0_N: U_A4.A10; also elsewhere on the board
A4_CH0_DQS0_P: U_A4.A9; also elsewhere on the board
A4_CH0_DQS1_N: U_A4.A22; also elsewhere on the board
A4_CH0_DQS1_P: U_A4.A21; also elsewhere on the board
A4_CH0_DQS2_N: U_A4.A34; also elsewhere on the board
A4_CH0_DQS2_P: U_A4.A33; also elsewhere on the board
A4_CH0_DQS3_N: U_A4.B11; also elsewhere on the board
A4_CH0_DQS3_P: U_A4.B10; also elsewhere on the board
A4_CH0_RESET: U_A4.B34; also elsewhere on the board
A4_CH1_CA0: U_A4.D14; also elsewhere on the board
A4_CH1_CA1: U_A4.D15; also elsewhere on the board
A4_CH1_CA2: U_A4.D16; also elsewhere on the board
A4_CH1_CA3: U_A4.D17; also elsewhere on the board
A4_CH1_CA4: U_A4.D18; also elsewhere on the board
A4_CH1_CA5: U_A4.D19; also elsewhere on the board
A4_CH1_CA6: U_A4.D20; also elsewhere on the board
A4_CH1_CA7: U_A4.D21; also elsewhere on the board
A4_CH1_CA8: U_A4.D22; also elsewhere on the board
A4_CH1_CA9: U_A4.D23; also elsewhere on the board
A4_CH1_CA10: U_A4.D24; also elsewhere on the board
A4_CH1_CA11: U_A4.D25; also elsewhere on the board
A4_CH1_CA12: U_A4.D26; also elsewhere on the board
A4_CH1_CA13: U_A4.D27; also elsewhere on the board
A4_CH1_CK0_N: U_A4.D31; also elsewhere on the board
A4_CH1_CK0_P: U_A4.D30; also elsewhere on the board
A4_CH1_CK1_N: U_A4.D33; also elsewhere on the board
A4_CH1_CK1_P: U_A4.D32; also elsewhere on the board
A4_CH1_CS0: U_A4.D28; also elsewhere on the board
A4_CH1_CS1: U_A4.D29; also elsewhere on the board
A4_CH1_DMI0: U_A4.C11; also elsewhere on the board
A4_CH1_DMI1: U_A4.C23; also elsewhere on the board
A4_CH1_DMI2: U_A4.C35; also elsewhere on the board
A4_CH1_DMI3: U_A4.D12; also elsewhere on the board
A4_CH1_DQ0: U_A4.C1; also elsewhere on the board
A4_CH1_DQ1: U_A4.C2; also elsewhere on the board
A4_CH1_DQ2: U_A4.C3; also elsewhere on the board
A4_CH1_DQ3: U_A4.C4; also elsewhere on the board
A4_CH1_DQ4: U_A4.C5; also elsewhere on the board
A4_CH1_DQ5: U_A4.C6; also elsewhere on the board
A4_CH1_DQ6: U_A4.C7; also elsewhere on the board
A4_CH1_DQ7: U_A4.C8; also elsewhere on the board
A4_CH1_DQ8: U_A4.C13; also elsewhere on the board
A4_CH1_DQ9: U_A4.C14; also elsewhere on the board
A4_CH1_DQ10: U_A4.C15; also elsewhere on the board
A4_CH1_DQ11: U_A4.C16; also elsewhere on the board
A4_CH1_DQ12: U_A4.C17; also elsewhere on the board
A4_CH1_DQ13: U_A4.C18; also elsewhere on the board
A4_CH1_DQ14: U_A4.C19; also elsewhere on the board
A4_CH1_DQ15: U_A4.C20; also elsewhere on the board
A4_CH1_DQ16: U_A4.C25; also elsewhere on the board
A4_CH1_DQ17: U_A4.C26; also elsewhere on the board
A4_CH1_DQ18: U_A4.C27; also elsewhere on the board
A4_CH1_DQ19: U_A4.C28; also elsewhere on the board
A4_CH1_DQ20: U_A4.C29; also elsewhere on the board
A4_CH1_DQ21: U_A4.C30; also elsewhere on the board
A4_CH1_DQ22: U_A4.C31; also elsewhere on the board
A4_CH1_DQ23: U_A4.C32; also elsewhere on the board
A4_CH1_DQ24: U_A4.D2; also elsewhere on the board
A4_CH1_DQ25: U_A4.D3; also elsewhere on the board
A4_CH1_DQ26: U_A4.D4; also elsewhere on the board
A4_CH1_DQ27: U_A4.D5; also elsewhere on the board
A4_CH1_DQ28: U_A4.D6; also elsewhere on the board
A4_CH1_DQ29: U_A4.D7; also elsewhere on the board
A4_CH1_DQ30: U_A4.D8; also elsewhere on the board
A4_CH1_DQ31: U_A4.D9; also elsewhere on the board
A4_CH1_DQS0_N: U_A4.C10; also elsewhere on the board
A4_CH1_DQS0_P: U_A4.C9; also elsewhere on the board
A4_CH1_DQS1_N: U_A4.C22; also elsewhere on the board
A4_CH1_DQS1_P: U_A4.C21; also elsewhere on the board
A4_CH1_DQS2_N: U_A4.C34; also elsewhere on the board
A4_CH1_DQS2_P: U_A4.C33; also elsewhere on the board
A4_CH1_DQS3_N: U_A4.D11; also elsewhere on the board
A4_CH1_DQS3_P: U_A4.D10; also elsewhere on the board
A4_CH1_RESET: U_A4.D34; also elsewhere on the board
A5_CH0_CA0: U_A5.B14; also elsewhere on the board
A5_CH0_CA1: U_A5.B15; also elsewhere on the board
A5_CH0_CA2: U_A5.B16; also elsewhere on the board
A5_CH0_CA3: U_A5.B17; also elsewhere on the board
A5_CH0_CA4: U_A5.B18; also elsewhere on the board
A5_CH0_CA5: U_A5.B19; also elsewhere on the board
A5_CH0_CA6: U_A5.B20; also elsewhere on the board
A5_CH0_CA7: U_A5.B21; also elsewhere on the board
A5_CH0_CA8: U_A5.B22; also elsewhere on the board
A5_CH0_CA9: U_A5.B23; also elsewhere on the board
A5_CH0_CA10: U_A5.B24; also elsewhere on the board
A5_CH0_CA11: U_A5.B25; also elsewhere on the board
A5_CH0_CA12: U_A5.B26; also elsewhere on the board
A5_CH0_CA13: U_A5.B27; also elsewhere on the board
A5_CH0_CK0_N: U_A5.B31; also elsewhere on the board
A5_CH0_CK0_P: U_A5.B30; also elsewhere on the board
A5_CH0_CK1_N: U_A5.B33; also elsewhere on the board
A5_CH0_CK1_P: U_A5.B32; also elsewhere on the board
A5_CH0_CS0: U_A5.B28; also elsewhere on the board
A5_CH0_CS1: U_A5.B29; also elsewhere on the board
A5_CH0_DMI0: U_A5.A11; also elsewhere on the board
A5_CH0_DMI1: U_A5.A23; also elsewhere on the board
A5_CH0_DMI2: U_A5.A35; also elsewhere on the board
A5_CH0_DMI3: U_A5.B12; also elsewhere on the board
A5_CH0_DQ0: U_A5.A1; also elsewhere on the board
A5_CH0_DQ1: U_A5.A2; also elsewhere on the board
A5_CH0_DQ2: U_A5.A3; also elsewhere on the board
A5_CH0_DQ3: U_A5.A4; also elsewhere on the board
A5_CH0_DQ4: U_A5.A5; also elsewhere on the board
A5_CH0_DQ5: U_A5.A6; also elsewhere on the board
A5_CH0_DQ6: U_A5.A7; also elsewhere on the board
A5_CH0_DQ7: U_A5.A8; also elsewhere on the board
A5_CH0_DQ8: U_A5.A13; also elsewhere on the board
A5_CH0_DQ9: U_A5.A14; also elsewhere on the board
A5_CH0_DQ10: U_A5.A15; also elsewhere on the board
A5_CH0_DQ11: U_A5.A16; also elsewhere on the board
A5_CH0_DQ12: U_A5.A17; also elsewhere on the board
A5_CH0_DQ13: U_A5.A18; also elsewhere on the board
A5_CH0_DQ14: U_A5.A19; also elsewhere on the board
A5_CH0_DQ15: U_A5.A20; also elsewhere on the board
A5_CH0_DQ16: U_A5.A25; also elsewhere on the board
A5_CH0_DQ17: U_A5.A26; also elsewhere on the board
A5_CH0_DQ18: U_A5.A27; also elsewhere on the board
A5_CH0_DQ19: U_A5.A28; also elsewhere on the board
A5_CH0_DQ20: U_A5.A29; also elsewhere on the board
A5_CH0_DQ21: U_A5.A30; also elsewhere on the board
A5_CH0_DQ22: U_A5.A31; also elsewhere on the board
A5_CH0_DQ23: U_A5.A32; also elsewhere on the board
A5_CH0_DQ24: U_A5.B2; also elsewhere on the board
A5_CH0_DQ25: U_A5.B3; also elsewhere on the board
A5_CH0_DQ26: U_A5.B4; also elsewhere on the board
A5_CH0_DQ27: U_A5.B5; also elsewhere on the board
A5_CH0_DQ28: U_A5.B6; also elsewhere on the board
A5_CH0_DQ29: U_A5.B7; also elsewhere on the board
A5_CH0_DQ30: U_A5.B8; also elsewhere on the board
A5_CH0_DQ31: U_A5.B9; also elsewhere on the board
A5_CH0_DQS0_N: U_A5.A10; also elsewhere on the board
A5_CH0_DQS0_P: U_A5.A9; also elsewhere on the board
A5_CH0_DQS1_N: U_A5.A22; also elsewhere on the board
A5_CH0_DQS1_P: U_A5.A21; also elsewhere on the board
A5_CH0_DQS2_N: U_A5.A34; also elsewhere on the board
A5_CH0_DQS2_P: U_A5.A33; also elsewhere on the board
A5_CH0_DQS3_N: U_A5.B11; also elsewhere on the board
A5_CH0_DQS3_P: U_A5.B10; also elsewhere on the board
A5_CH0_RESET: U_A5.B34; also elsewhere on the board
A5_CH1_CA0: U_A5.D14; also elsewhere on the board
A5_CH1_CA1: U_A5.D15; also elsewhere on the board
A5_CH1_CA2: U_A5.D16; also elsewhere on the board
A5_CH1_CA3: U_A5.D17; also elsewhere on the board
A5_CH1_CA4: U_A5.D18; also elsewhere on the board
A5_CH1_CA5: U_A5.D19; also elsewhere on the board
A5_CH1_CA6: U_A5.D20; also elsewhere on the board
A5_CH1_CA7: U_A5.D21; also elsewhere on the board
A5_CH1_CA8: U_A5.D22; also elsewhere on the board
A5_CH1_CA9: U_A5.D23; also elsewhere on the board
A5_CH1_CA10: U_A5.D24; also elsewhere on the board
A5_CH1_CA11: U_A5.D25; also elsewhere on the board
A5_CH1_CA12: U_A5.D26; also elsewhere on the board
A5_CH1_CA13: U_A5.D27; also elsewhere on the board
A5_CH1_CK0_N: U_A5.D31; also elsewhere on the board
A5_CH1_CK0_P: U_A5.D30; also elsewhere on the board
A5_CH1_CK1_N: U_A5.D33; also elsewhere on the board
A5_CH1_CK1_P: U_A5.D32; also elsewhere on the board
A5_CH1_CS0: U_A5.D28; also elsewhere on the board
A5_CH1_CS1: U_A5.D29; also elsewhere on the board
A5_CH1_DMI0: U_A5.C11; also elsewhere on the board
A5_CH1_DMI1: U_A5.C23; also elsewhere on the board
A5_CH1_DMI2: U_A5.C35; also elsewhere on the board
A5_CH1_DMI3: U_A5.D12; also elsewhere on the board
A5_CH1_DQ0: U_A5.C1; also elsewhere on the board
A5_CH1_DQ1: U_A5.C2; also elsewhere on the board
A5_CH1_DQ2: U_A5.C3; also elsewhere on the board
A5_CH1_DQ3: U_A5.C4; also elsewhere on the board
A5_CH1_DQ4: U_A5.C5; also elsewhere on the board
A5_CH1_DQ5: U_A5.C6; also elsewhere on the board
A5_CH1_DQ6: U_A5.C7; also elsewhere on the board
A5_CH1_DQ7: U_A5.C8; also elsewhere on the board
A5_CH1_DQ8: U_A5.C13; also elsewhere on the board
A5_CH1_DQ9: U_A5.C14; also elsewhere on the board
A5_CH1_DQ10: U_A5.C15; also elsewhere on the board
A5_CH1_DQ11: U_A5.C16; also elsewhere on the board
A5_CH1_DQ12: U_A5.C17; also elsewhere on the board
A5_CH1_DQ13: U_A5.C18; also elsewhere on the board
A5_CH1_DQ14: U_A5.C19; also elsewhere on the board
A5_CH1_DQ15: U_A5.C20; also elsewhere on the board
A5_CH1_DQ16: U_A5.C25; also elsewhere on the board
A5_CH1_DQ17: U_A5.C26; also elsewhere on the board
A5_CH1_DQ18: U_A5.C27; also elsewhere on the board
A5_CH1_DQ19: U_A5.C28; also elsewhere on the board
A5_CH1_DQ20: U_A5.C29; also elsewhere on the board
A5_CH1_DQ21: U_A5.C30; also elsewhere on the board
A5_CH1_DQ22: U_A5.C31; also elsewhere on the board
A5_CH1_DQ23: U_A5.C32; also elsewhere on the board
A5_CH1_DQ24: U_A5.D2; also elsewhere on the board
A5_CH1_DQ25: U_A5.D3; also elsewhere on the board
A5_CH1_DQ26: U_A5.D4; also elsewhere on the board
A5_CH1_DQ27: U_A5.D5; also elsewhere on the board
A5_CH1_DQ28: U_A5.D6; also elsewhere on the board
A5_CH1_DQ29: U_A5.D7; also elsewhere on the board
A5_CH1_DQ30: U_A5.D8; also elsewhere on the board
A5_CH1_DQ31: U_A5.D9; also elsewhere on the board
A5_CH1_DQS0_N: U_A5.C10; also elsewhere on the board
A5_CH1_DQS0_P: U_A5.C9; also elsewhere on the board
A5_CH1_DQS1_N: U_A5.C22; also elsewhere on the board
A5_CH1_DQS1_P: U_A5.C21; also elsewhere on the board
A5_CH1_DQS2_N: U_A5.C34; also elsewhere on the board
A5_CH1_DQS2_P: U_A5.C33; also elsewhere on the board
A5_CH1_DQS3_N: U_A5.D11; also elsewhere on the board
A5_CH1_DQS3_P: U_A5.D10; also elsewhere on the board
A5_CH1_RESET: U_A5.D34; also elsewhere on the board
A6_CH0_CA0: U_A6.B14; also elsewhere on the board
A6_CH0_CA1: U_A6.B15; also elsewhere on the board
A6_CH0_CA2: U_A6.B16; also elsewhere on the board
A6_CH0_CA3: U_A6.B17; also elsewhere on the board
A6_CH0_CA4: U_A6.B18; also elsewhere on the board
A6_CH0_CA5: U_A6.B19; also elsewhere on the board
A6_CH0_CA6: U_A6.B20; also elsewhere on the board
A6_CH0_CA7: U_A6.B21; also elsewhere on the board
A6_CH0_CA8: U_A6.B22; also elsewhere on the board
A6_CH0_CA9: U_A6.B23; also elsewhere on the board
A6_CH0_CA10: U_A6.B24; also elsewhere on the board
A6_CH0_CA11: U_A6.B25; also elsewhere on the board
A6_CH0_CA12: U_A6.B26; also elsewhere on the board
A6_CH0_CA13: U_A6.B27; also elsewhere on the board
A6_CH0_CK0_N: U_A6.B31; also elsewhere on the board
A6_CH0_CK0_P: U_A6.B30; also elsewhere on the board
A6_CH0_CK1_N: U_A6.B33; also elsewhere on the board
A6_CH0_CK1_P: U_A6.B32; also elsewhere on the board
A6_CH0_CS0: U_A6.B28; also elsewhere on the board
A6_CH0_CS1: U_A6.B29; also elsewhere on the board
A6_CH0_DMI0: U_A6.A11; also elsewhere on the board
A6_CH0_DMI1: U_A6.A23; also elsewhere on the board
A6_CH0_DMI2: U_A6.A35; also elsewhere on the board
A6_CH0_DMI3: U_A6.B12; also elsewhere on the board
A6_CH0_DQ0: U_A6.A1; also elsewhere on the board
A6_CH0_DQ1: U_A6.A2; also elsewhere on the board
A6_CH0_DQ2: U_A6.A3; also elsewhere on the board
A6_CH0_DQ3: U_A6.A4; also elsewhere on the board
A6_CH0_DQ4: U_A6.A5; also elsewhere on the board
A6_CH0_DQ5: U_A6.A6; also elsewhere on the board
A6_CH0_DQ6: U_A6.A7; also elsewhere on the board
A6_CH0_DQ7: U_A6.A8; also elsewhere on the board
A6_CH0_DQ8: U_A6.A13; also elsewhere on the board
A6_CH0_DQ9: U_A6.A14; also elsewhere on the board
A6_CH0_DQ10: U_A6.A15; also elsewhere on the board
A6_CH0_DQ11: U_A6.A16; also elsewhere on the board
A6_CH0_DQ12: U_A6.A17; also elsewhere on the board
A6_CH0_DQ13: U_A6.A18; also elsewhere on the board
A6_CH0_DQ14: U_A6.A19; also elsewhere on the board
A6_CH0_DQ15: U_A6.A20; also elsewhere on the board
A6_CH0_DQ16: U_A6.A25; also elsewhere on the board
A6_CH0_DQ17: U_A6.A26; also elsewhere on the board
A6_CH0_DQ18: U_A6.A27; also elsewhere on the board
A6_CH0_DQ19: U_A6.A28; also elsewhere on the board
A6_CH0_DQ20: U_A6.A29; also elsewhere on the board
A6_CH0_DQ21: U_A6.A30; also elsewhere on the board
A6_CH0_DQ22: U_A6.A31; also elsewhere on the board
A6_CH0_DQ23: U_A6.A32; also elsewhere on the board
A6_CH0_DQ24: U_A6.B2; also elsewhere on the board
A6_CH0_DQ25: U_A6.B3; also elsewhere on the board
A6_CH0_DQ26: U_A6.B4; also elsewhere on the board
A6_CH0_DQ27: U_A6.B5; also elsewhere on the board
A6_CH0_DQ28: U_A6.B6; also elsewhere on the board
A6_CH0_DQ29: U_A6.B7; also elsewhere on the board
A6_CH0_DQ30: U_A6.B8; also elsewhere on the board
A6_CH0_DQ31: U_A6.B9; also elsewhere on the board
A6_CH0_DQS0_N: U_A6.A10; also elsewhere on the board
A6_CH0_DQS0_P: U_A6.A9; also elsewhere on the board
A6_CH0_DQS1_N: U_A6.A22; also elsewhere on the board
A6_CH0_DQS1_P: U_A6.A21; also elsewhere on the board
A6_CH0_DQS2_N: U_A6.A34; also elsewhere on the board
A6_CH0_DQS2_P: U_A6.A33; also elsewhere on the board
A6_CH0_DQS3_N: U_A6.B11; also elsewhere on the board
A6_CH0_DQS3_P: U_A6.B10; also elsewhere on the board
A6_CH0_RESET: U_A6.B34; also elsewhere on the board
A6_CH1_CA0: U_A6.D14; also elsewhere on the board
A6_CH1_CA1: U_A6.D15; also elsewhere on the board
A6_CH1_CA2: U_A6.D16; also elsewhere on the board
A6_CH1_CA3: U_A6.D17; also elsewhere on the board
A6_CH1_CA4: U_A6.D18; also elsewhere on the board
A6_CH1_CA5: U_A6.D19; also elsewhere on the board
A6_CH1_CA6: U_A6.D20; also elsewhere on the board
A6_CH1_CA7: U_A6.D21; also elsewhere on the board
A6_CH1_CA8: U_A6.D22; also elsewhere on the board
A6_CH1_CA9: U_A6.D23; also elsewhere on the board
A6_CH1_CA10: U_A6.D24; also elsewhere on the board
A6_CH1_CA11: U_A6.D25; also elsewhere on the board
A6_CH1_CA12: U_A6.D26; also elsewhere on the board
A6_CH1_CA13: U_A6.D27; also elsewhere on the board
A6_CH1_CK0_N: U_A6.D31; also elsewhere on the board
A6_CH1_CK0_P: U_A6.D30; also elsewhere on the board
A6_CH1_CK1_N: U_A6.D33; also elsewhere on the board
A6_CH1_CK1_P: U_A6.D32; also elsewhere on the board
A6_CH1_CS0: U_A6.D28; also elsewhere on the board
A6_CH1_CS1: U_A6.D29; also elsewhere on the board
A6_CH1_DMI0: U_A6.C11; also elsewhere on the board
A6_CH1_DMI1: U_A6.C23; also elsewhere on the board
A6_CH1_DMI2: U_A6.C35; also elsewhere on the board
A6_CH1_DMI3: U_A6.D12; also elsewhere on the board
A6_CH1_DQ0: U_A6.C1; also elsewhere on the board
A6_CH1_DQ1: U_A6.C2; also elsewhere on the board
A6_CH1_DQ2: U_A6.C3; also elsewhere on the board
A6_CH1_DQ3: U_A6.C4; also elsewhere on the board
A6_CH1_DQ4: U_A6.C5; also elsewhere on the board
A6_CH1_DQ5: U_A6.C6; also elsewhere on the board
A6_CH1_DQ6: U_A6.C7; also elsewhere on the board
A6_CH1_DQ7: U_A6.C8; also elsewhere on the board
A6_CH1_DQ8: U_A6.C13; also elsewhere on the board
A6_CH1_DQ9: U_A6.C14; also elsewhere on the board
A6_CH1_DQ10: U_A6.C15; also elsewhere on the board
A6_CH1_DQ11: U_A6.C16; also elsewhere on the board
A6_CH1_DQ12: U_A6.C17; also elsewhere on the board
A6_CH1_DQ13: U_A6.C18; also elsewhere on the board
A6_CH1_DQ14: U_A6.C19; also elsewhere on the board
A6_CH1_DQ15: U_A6.C20; also elsewhere on the board
A6_CH1_DQ16: U_A6.C25; also elsewhere on the board
A6_CH1_DQ17: U_A6.C26; also elsewhere on the board
A6_CH1_DQ18: U_A6.C27; also elsewhere on the board
A6_CH1_DQ19: U_A6.C28; also elsewhere on the board
A6_CH1_DQ20: U_A6.C29; also elsewhere on the board
A6_CH1_DQ21: U_A6.C30; also elsewhere on the board
A6_CH1_DQ22: U_A6.C31; also elsewhere on the board
A6_CH1_DQ23: U_A6.C32; also elsewhere on the board
A6_CH1_DQ24: U_A6.D2; also elsewhere on the board
A6_CH1_DQ25: U_A6.D3; also elsewhere on the board
A6_CH1_DQ26: U_A6.D4; also elsewhere on the board
A6_CH1_DQ27: U_A6.D5; also elsewhere on the board
A6_CH1_DQ28: U_A6.D6; also elsewhere on the board
A6_CH1_DQ29: U_A6.D7; also elsewhere on the board
A6_CH1_DQ30: U_A6.D8; also elsewhere on the board
A6_CH1_DQ31: U_A6.D9; also elsewhere on the board
A6_CH1_DQS0_N: U_A6.C10; also elsewhere on the board
A6_CH1_DQS0_P: U_A6.C9; also elsewhere on the board
A6_CH1_DQS1_N: U_A6.C22; also elsewhere on the board
A6_CH1_DQS1_P: U_A6.C21; also elsewhere on the board
A6_CH1_DQS2_N: U_A6.C34; also elsewhere on the board
A6_CH1_DQS2_P: U_A6.C33; also elsewhere on the board
A6_CH1_DQS3_N: U_A6.D11; also elsewhere on the board
A6_CH1_DQS3_P: U_A6.D10; also elsewhere on the board
A6_CH1_RESET: U_A6.D34; also elsewhere on the board
A7_CH0_CA0: U_A7.B14; also elsewhere on the board
A7_CH0_CA1: U_A7.B15; also elsewhere on the board
A7_CH0_CA2: U_A7.B16; also elsewhere on the board
A7_CH0_CA3: U_A7.B17; also elsewhere on the board
A7_CH0_CA4: U_A7.B18; also elsewhere on the board
A7_CH0_CA5: U_A7.B19; also elsewhere on the board
A7_CH0_CA6: U_A7.B20; also elsewhere on the board
A7_CH0_CA7: U_A7.B21; also elsewhere on the board
A7_CH0_CA8: U_A7.B22; also elsewhere on the board
A7_CH0_CA9: U_A7.B23; also elsewhere on the board
A7_CH0_CA10: U_A7.B24; also elsewhere on the board
A7_CH0_CA11: U_A7.B25; also elsewhere on the board
A7_CH0_CA12: U_A7.B26; also elsewhere on the board
A7_CH0_CA13: U_A7.B27; also elsewhere on the board
A7_CH0_CK0_N: U_A7.B31; also elsewhere on the board
A7_CH0_CK0_P: U_A7.B30; also elsewhere on the board
A7_CH0_CK1_N: U_A7.B33; also elsewhere on the board
A7_CH0_CK1_P: U_A7.B32; also elsewhere on the board
A7_CH0_CS0: U_A7.B28; also elsewhere on the board
A7_CH0_CS1: U_A7.B29; also elsewhere on the board
A7_CH0_DMI0: U_A7.A11; also elsewhere on the board
A7_CH0_DMI1: U_A7.A23; also elsewhere on the board
A7_CH0_DMI2: U_A7.A35; also elsewhere on the board
A7_CH0_DMI3: U_A7.B12; also elsewhere on the board
A7_CH0_DQ0: U_A7.A1; also elsewhere on the board
A7_CH0_DQ1: U_A7.A2; also elsewhere on the board
A7_CH0_DQ2: U_A7.A3; also elsewhere on the board
A7_CH0_DQ3: U_A7.A4; also elsewhere on the board
A7_CH0_DQ4: U_A7.A5; also elsewhere on the board
A7_CH0_DQ5: U_A7.A6; also elsewhere on the board
A7_CH0_DQ6: U_A7.A7; also elsewhere on the board
A7_CH0_DQ7: U_A7.A8; also elsewhere on the board
A7_CH0_DQ8: U_A7.A13; also elsewhere on the board
A7_CH0_DQ9: U_A7.A14; also elsewhere on the board
A7_CH0_DQ10: U_A7.A15; also elsewhere on the board
A7_CH0_DQ11: U_A7.A16; also elsewhere on the board
A7_CH0_DQ12: U_A7.A17; also elsewhere on the board
A7_CH0_DQ13: U_A7.A18; also elsewhere on the board
A7_CH0_DQ14: U_A7.A19; also elsewhere on the board
A7_CH0_DQ15: U_A7.A20; also elsewhere on the board
A7_CH0_DQ16: U_A7.A25; also elsewhere on the board
A7_CH0_DQ17: U_A7.A26; also elsewhere on the board
A7_CH0_DQ18: U_A7.A27; also elsewhere on the board
A7_CH0_DQ19: U_A7.A28; also elsewhere on the board
A7_CH0_DQ20: U_A7.A29; also elsewhere on the board
A7_CH0_DQ21: U_A7.A30; also elsewhere on the board
A7_CH0_DQ22: U_A7.A31; also elsewhere on the board
A7_CH0_DQ23: U_A7.A32; also elsewhere on the board
A7_CH0_DQ24: U_A7.B2; also elsewhere on the board
A7_CH0_DQ25: U_A7.B3; also elsewhere on the board
A7_CH0_DQ26: U_A7.B4; also elsewhere on the board
A7_CH0_DQ27: U_A7.B5; also elsewhere on the board
A7_CH0_DQ28: U_A7.B6; also elsewhere on the board
A7_CH0_DQ29: U_A7.B7; also elsewhere on the board
A7_CH0_DQ30: U_A7.B8; also elsewhere on the board
A7_CH0_DQ31: U_A7.B9; also elsewhere on the board
A7_CH0_DQS0_N: U_A7.A10; also elsewhere on the board
A7_CH0_DQS0_P: U_A7.A9; also elsewhere on the board
A7_CH0_DQS1_N: U_A7.A22; also elsewhere on the board
A7_CH0_DQS1_P: U_A7.A21; also elsewhere on the board
A7_CH0_DQS2_N: U_A7.A34; also elsewhere on the board
A7_CH0_DQS2_P: U_A7.A33; also elsewhere on the board
A7_CH0_DQS3_N: U_A7.B11; also elsewhere on the board
A7_CH0_DQS3_P: U_A7.B10; also elsewhere on the board
A7_CH0_RESET: U_A7.B34; also elsewhere on the board
A7_CH1_CA0: U_A7.D14; also elsewhere on the board
A7_CH1_CA1: U_A7.D15; also elsewhere on the board
A7_CH1_CA2: U_A7.D16; also elsewhere on the board
A7_CH1_CA3: U_A7.D17; also elsewhere on the board
A7_CH1_CA4: U_A7.D18; also elsewhere on the board
A7_CH1_CA5: U_A7.D19; also elsewhere on the board
A7_CH1_CA6: U_A7.D20; also elsewhere on the board
A7_CH1_CA7: U_A7.D21; also elsewhere on the board
A7_CH1_CA8: U_A7.D22; also elsewhere on the board
A7_CH1_CA9: U_A7.D23; also elsewhere on the board
A7_CH1_CA10: U_A7.D24; also elsewhere on the board
A7_CH1_CA11: U_A7.D25; also elsewhere on the board
A7_CH1_CA12: U_A7.D26; also elsewhere on the board
A7_CH1_CA13: U_A7.D27; also elsewhere on the board
A7_CH1_CK0_N: U_A7.D31; also elsewhere on the board
A7_CH1_CK0_P: U_A7.D30; also elsewhere on the board
A7_CH1_CK1_N: U_A7.D33; also elsewhere on the board
A7_CH1_CK1_P: U_A7.D32; also elsewhere on the board
A7_CH1_CS0: U_A7.D28; also elsewhere on the board
A7_CH1_CS1: U_A7.D29; also elsewhere on the board
A7_CH1_DMI0: U_A7.C11; also elsewhere on the board
A7_CH1_DMI1: U_A7.C23; also elsewhere on the board
A7_CH1_DMI2: U_A7.C35; also elsewhere on the board
A7_CH1_DMI3: U_A7.D12; also elsewhere on the board
A7_CH1_DQ0: U_A7.C1; also elsewhere on the board
A7_CH1_DQ1: U_A7.C2; also elsewhere on the board
A7_CH1_DQ2: U_A7.C3; also elsewhere on the board
A7_CH1_DQ3: U_A7.C4; also elsewhere on the board
A7_CH1_DQ4: U_A7.C5; also elsewhere on the board
A7_CH1_DQ5: U_A7.C6; also elsewhere on the board
A7_CH1_DQ6: U_A7.C7; also elsewhere on the board
A7_CH1_DQ7: U_A7.C8; also elsewhere on the board
A7_CH1_DQ8: U_A7.C13; also elsewhere on the board
A7_CH1_DQ9: U_A7.C14; also elsewhere on the board
A7_CH1_DQ10: U_A7.C15; also elsewhere on the board
A7_CH1_DQ11: U_A7.C16; also elsewhere on the board
A7_CH1_DQ12: U_A7.C17; also elsewhere on the board
A7_CH1_DQ13: U_A7.C18; also elsewhere on the board
A7_CH1_DQ14: U_A7.C19; also elsewhere on the board
A7_CH1_DQ15: U_A7.C20; also elsewhere on the board
A7_CH1_DQ16: U_A7.C25; also elsewhere on the board
A7_CH1_DQ17: U_A7.C26; also elsewhere on the board
A7_CH1_DQ18: U_A7.C27; also elsewhere on the board
A7_CH1_DQ19: U_A7.C28; also elsewhere on the board
A7_CH1_DQ20: U_A7.C29; also elsewhere on the board
A7_CH1_DQ21: U_A7.C30; also elsewhere on the board
A7_CH1_DQ22: U_A7.C31; also elsewhere on the board
A7_CH1_DQ23: U_A7.C32; also elsewhere on the board
A7_CH1_DQ24: U_A7.D2; also elsewhere on the board
A7_CH1_DQ25: U_A7.D3; also elsewhere on the board
A7_CH1_DQ26: U_A7.D4; also elsewhere on the board
A7_CH1_DQ27: U_A7.D5; also elsewhere on the board
A7_CH1_DQ28: U_A7.D6; also elsewhere on the board
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