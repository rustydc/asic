# Repository rustydc/asic (continued)

## KiCad design hw/kicad_psram/module.kicad_pcb

Schematic: module_asics.kicad_sch

Parts:
J_EDGE: card-edge fingers; PCIE_X16_FINGERS
U_CHIP: layer_asic; FCBGA784_28x28_P0.8

Connections:
+12V: J_EDGE.A1, J_EDGE.A2, J_EDGE.A3, J_EDGE.A4, J_EDGE.A5, J_EDGE.A6, J_EDGE.B1, J_EDGE.B2, J_EDGE.B3, J_EDGE.B4, J_EDGE.B5, J_EDGE.B6; also elsewhere on the board
GND: J_EDGE.A7, J_EDGE.A8, J_EDGE.A9, J_EDGE.A10, J_EDGE.A11, J_EDGE.A24, J_EDGE.A25, J_EDGE.A26, J_EDGE.A27, J_EDGE.A28, J_EDGE.A29, J_EDGE.A30, J_EDGE.A31, J_EDGE.A32, J_EDGE.A33, J_EDGE.A34, J_EDGE.A35, J_EDGE.A36, J_EDGE.A37, J_EDGE.A38, J_EDGE.A39, J_EDGE.A40, J_EDGE.A41, J_EDGE.A42, J_EDGE.A43, J_EDGE.A44, J_EDGE.A45, J_EDGE.A46, J_EDGE.A47, J_EDGE.A48, J_EDGE.A49, J_EDGE.A64, J_EDGE.A65, J_EDGE.A66, J_EDGE.A67, J_EDGE.A68, J_EDGE.A69, J_EDGE.A70, J_EDGE.A71, J_EDGE.A72, J_EDGE.A73, J_EDGE.A74, J_EDGE.A75, J_EDGE.A76, J_EDGE.A77, J_EDGE.A78, J_EDGE.A79, J_EDGE.A80, J_EDGE.A81, J_EDGE.A82, J_EDGE.B7, J_EDGE.B8, J_EDGE.B9, J_EDGE.B10, J_EDGE.B11, J_EDGE.B24, J_EDGE.B25, J_EDGE.B26, J_EDGE.B27, J_EDGE.B28, J_EDGE.B29, J_EDGE.B30, J_EDGE.B31, J_EDGE.B32, J_EDGE.B33, J_EDGE.B34, J_EDGE.B35, J_EDGE.B36, J_EDGE.B37, J_EDGE.B38, J_EDGE.B39, J_EDGE.B40, J_EDGE.B41, J_EDGE.B42, J_EDGE.B43, J_EDGE.B44, J_EDGE.B45, J_EDGE.B46, J_EDGE.B47, J_EDGE.B48, J_EDGE.B49, J_EDGE.B54, J_EDGE.B55, J_EDGE.B56, J_EDGE.B57, J_EDGE.B58, J_EDGE.B59, J_EDGE.B60, J_EDGE.B61, J_EDGE.B62, J_EDGE.B63, J_EDGE.B64, J_EDGE.B65, J_EDGE.B66, J_EDGE.B67, J_EDGE.B68, J_EDGE.B69, J_EDGE.B70, J_EDGE.B71, J_EDGE.B72, J_EDGE.B73, J_EDGE.B74, J_EDGE.B75, J_EDGE.B76, J_EDGE.B77, J_EDGE.B78, J_EDGE.B79, J_EDGE.B80, J_EDGE.B81, J_EDGE.B82, U_CHIP.AA7, U_CHIP.AA9, U_CHIP.AA11, U_CHIP.AA13, U_CHIP.AA15, U_CHIP.AA17, U_CHIP.AA19, U_CHIP.AA21, U_CHIP.AA23, U_CHIP.AA28, U_CHIP.AB6, U_CHIP.AB8, U_CHIP.AB10, U_CHIP.AB12, U_CHIP.AB14, U_CHIP.AB16, U_CHIP.AB18, U_CHIP.AB20, U_CHIP.AB22, U_CHIP.AC5, U_CHIP.AC7, U_CHIP.AC9, U_CHIP.AC11, U_CHIP.AC13, U_CHIP.AC15, U_CHIP.AC17, U_CHIP.AC19, U_CHIP.AC21, U_CHIP.AC23, U_CHIP.AD2, U_CHIP.AD4, U_CHIP.AD6, U_CHIP.AD8, U_CHIP.AD10, U_CHIP.AD12, U_CHIP.AD14, U_CHIP.AD16, U_CHIP.AD18, U_CHIP.AD20, U_CHIP.AD22, U_CHIP.AD24, U_CHIP.AD26, U_CHIP.AD28, U_CHIP.AE1, U_CHIP.AE3, U_CHIP.AE5, U_CHIP.AE7, U_CHIP.AE9, U_CHIP.AE11, U_CHIP.AE13, U_CHIP.AE15, U_CHIP.AE17, U_CHIP.AE19, U_CHIP.AE21, U_CHIP.AE23, U_CHIP.AE25, U_CHIP.AE27, U_CHIP.AF2, U_CHIP.AF4, U_CHIP.AF6, U_CHIP.AF8, U_CHIP.AF10, U_CHIP.AF12, U_CHIP.AF14, U_CHIP.AF16, U_CHIP.AF18, U_CHIP.AF20, U_CHIP.AF22, U_CHIP.AF24, U_CHIP.AF26, U_CHIP.AF28, U_CHIP.AG1, U_CHIP.AG10, U_CHIP.AG13, U_CHIP.AG15, U_CHIP.AG17, U_CHIP.AG19, U_CHIP.AG21, U_CHIP.AH2, U_CHIP.AH13, U_CHIP.AH18, U_CHIP.AH28, U_CHIP.E4, U_CHIP.E8, U_CHIP.E12, U_CHIP.E16, U_CHIP.E20, U_CHIP.E24, U_CHIP.E28, U_CHIP.F22, U_CHIP.G5, U_CHIP.G7, U_CHIP.G9, U_CHIP.G11, U_CHIP.G13, U_CHIP.G15, U_CHIP.G17, U_CHIP.G19, U_CHIP.G21, U_CHIP.G23, U_CHIP.H6, U_CHIP.H8, U_CHIP.H10, U_CHIP.H12, U_CHIP.H14, U_CHIP.H16, U_CHIP.H18, U_CHIP.H20, U_CHIP.H22, U_CHIP.J7, U_CHIP.J9, U_CHIP.J11, U_CHIP.J13, U_CHIP.J15, U_CHIP.J17, U_CHIP.J19, U_CHIP.J21, U_CHIP.J23, U_CHIP.J28, U_CHIP.K6, U_CHIP.K8, U_CHIP.K10, U_CHIP.K12, U_CHIP.K14, U_CHIP.K16, U_CHIP.K18, U_CHIP.K20, U_CHIP.K22, U_CHIP.L5, U_CHIP.L7, U_CHIP.L9, U_CHIP.L11, U_CHIP.L13, U_CHIP.L15, U_CHIP.L17, U_CHIP.L19, U_CHIP.L21, U_CHIP.L23, U_CHIP.M6, U_CHIP.M8, U_CHIP.M10, U_CHIP.M12, U_CHIP.M14, U_CHIP.M16, U_CHIP.M18, U_CHIP.M20, U_CHIP.M22, U_CHIP.N7, U_CHIP.N9, U_CHIP.N11, U_CHIP.N13, U_CHIP.N15, U_CHIP.N17, U_CHIP.N19, U_CHIP.N21, U_CHIP.N23, U_CHIP.N28, U_CHIP.P6, U_CHIP.P8, U_CHIP.P10, U_CHIP.P12, U_CHIP.P14, U_CHIP.P16, U_CHIP.P18, U_CHIP.P20, U_CHIP.P22, U_CHIP.R5, U_CHIP.R7, U_CHIP.R9, U_CHIP.R11, U_CHIP.R13, U_CHIP.R15, U_CHIP.R17, U_CHIP.R19, U_CHIP.R21, U_CHIP.R23, U_CHIP.T6, U_CHIP.T8, U_CHIP.T10, U_CHIP.T12, U_CHIP.T14, U_CHIP.T16, U_CHIP.T18, U_CHIP.T20, U_CHIP.T22, U_CHIP.U7, U_CHIP.U9, U_CHIP.U11, U_CHIP.U13, U_CHIP.U15, U_CHIP.U17, U_CHIP.U19, U_CHIP.U21, U_CHIP.U23, U_CHIP.U28, U_CHIP.V6, U_CHIP.V8, U_CHIP.V10, U_CHIP.V12, U_CHIP.V14, U_CHIP.V16, U_CHIP.V18, U_CHIP.V20, U_CHIP.V22, U_CHIP.W5, U_CHIP.W7, U_CHIP.W9, U_CHIP.W11, U_CHIP.W13, U_CHIP.W15, U_CHIP.W17, U_CHIP.W19, U_CHIP.W21, U_CHIP.W23, U_CHIP.Y6, U_CHIP.Y8, U_CHIP.Y10, U_CHIP.Y12, U_CHIP.Y14, U_CHIP.Y16, U_CHIP.Y18, U_CHIP.Y20, U_CHIP.Y22; also elsewhere on the board
JTAG_TCK: J_EDGE.A55, U_CHIP.AH15
JTAG_TDI: J_EDGE.A57, U_CHIP.AH17
JTAG_TDO: J_EDGE.A58, U_CHIP.AH19
JTAG_TMS: J_EDGE.A56, U_CHIP.AH16
JTAG_TRST: J_EDGE.A59, U_CHIP.AH20
LINK_IN_CLOCK: J_EDGE.A20, U_CHIP.AH7
LINK_IN_DATA0: J_EDGE.A12, U_CHIP.AH3
LINK_IN_DATA1: J_EDGE.A13, U_CHIP.AG3
LINK_IN_DATA2: J_EDGE.A14, U_CHIP.AH4
LINK_IN_DATA3: J_EDGE.A15, U_CHIP.AG4
LINK_IN_DATA4: J_EDGE.A16, U_CHIP.AH5
LINK_IN_DATA5: J_EDGE.A17, U_CHIP.AG5
LINK_IN_DATA6: J_EDGE.A18, U_CHIP.AH6
LINK_IN_DATA7: J_EDGE.A19, U_CHIP.AG6
LINK_IN_READY_BACK: J_EDGE.A22, U_CHIP.AH8
LINK_IN_SOF: J_EDGE.A23, U_CHIP.AG8
LINK_IN_VALID: J_EDGE.A21, U_CHIP.AG7
LINK_OUT_CLOCK: J_EDGE.B20, U_CHIP.AH26
LINK_OUT_DATA0: J_EDGE.B12, U_CHIP.AH22
LINK_OUT_DATA1: J_EDGE.B13, U_CHIP.AG22
LINK_OUT_DATA2: J_EDGE.B14, U_CHIP.AH23
LINK_OUT_DATA3: J_EDGE.B15, U_CHIP.AG23
LINK_OUT_DATA4: J_EDGE.B16, U_CHIP.AH24
LINK_OUT_DATA5: J_EDGE.B17, U_CHIP.AG24
LINK_OUT_DATA6: J_EDGE.B18, U_CHIP.AH25
LINK_OUT_DATA7: J_EDGE.B19, U_CHIP.AG25
LINK_OUT_READY_BACK: J_EDGE.B22, U_CHIP.AH27
LINK_OUT_SOF: J_EDGE.B23, U_CHIP.AG27
LINK_OUT_VALID: J_EDGE.B21, U_CHIP.AG26
MGMT_CS: J_EDGE.A53, U_CHIP.AH12
MGMT_IRQ: J_EDGE.A54, U_CHIP.AH14
MGMT_MISO: J_EDGE.A52, U_CHIP.AH11
MGMT_MOSI: J_EDGE.A51, U_CHIP.AH10
MGMT_SCLK: J_EDGE.A50, U_CHIP.AH9
MODE0: U_CHIP.AG11
MODE1: U_CHIP.AG12
PMB_SCL: J_EDGE.B50; also elsewhere on the board
PMB_SDA: J_EDGE.B51; also elsewhere on the board
PRSNT: J_EDGE.B53
PSRAM_0_CE: U_CHIP.D4
PSRAM_0_DQ0: U_CHIP.A1
PSRAM_0_DQ1: U_CHIP.B1
PSRAM_0_DQ2: U_CHIP.C1
PSRAM_0_DQ3: U_CHIP.D1
PSRAM_0_DQ4: U_CHIP.E1
PSRAM_0_DQ5: U_CHIP.A2
PSRAM_0_DQ6: U_CHIP.B2
PSRAM_0_DQ7: U_CHIP.C2
PSRAM_0_DQ8: U_CHIP.D2
PSRAM_0_DQ9: U_CHIP.E2
PSRAM_0_DQ10: U_CHIP.A3
PSRAM_0_DQ11: U_CHIP.B3
PSRAM_0_DQ12: U_CHIP.C3
PSRAM_0_DQ13: U_CHIP.D3
PSRAM_0_DQ14: U_CHIP.E3
PSRAM_0_DQ15: U_CHIP.A4
PSRAM_0_DQS0: U_CHIP.B4
PSRAM_0_DQS1: U_CHIP.C4
PSRAM_1_CE: U_CHIP.D8
PSRAM_1_DQ0: U_CHIP.A5
PSRAM_1_DQ1: U_CHIP.B5
PSRAM_1_DQ2: U_CHIP.C5
PSRAM_1_DQ3: U_CHIP.D5
PSRAM_1_DQ4: U_CHIP.E5
PSRAM_1_DQ5: U_CHIP.A6
PSRAM_1_DQ6: U_CHIP.B6
PSRAM_1_DQ7: U_CHIP.C6
PSRAM_1_DQ8: U_CHIP.D6
PSRAM_1_DQ9: U_CHIP.E6
PSRAM_1_DQ10: U_CHIP.A7
PSRAM_1_DQ11: U_CHIP.B7
PSRAM_1_DQ12: U_CHIP.C7
PSRAM_1_DQ13: U_CHIP.D7
PSRAM_1_DQ14: U_CHIP.E7
PSRAM_1_DQ15: U_CHIP.A8
PSRAM_1_DQS0: U_CHIP.B8
PSRAM_1_DQS1: U_CHIP.C8
PSRAM_2_CE: U_CHIP.N27
PSRAM_2_DQ0: U_CHIP.K24
PSRAM_2_DQ1: U_CHIP.K25
PSRAM_2_DQ2: U_CHIP.K26
PSRAM_2_DQ3: U_CHIP.K27
PSRAM_2_DQ4: U_CHIP.K28
PSRAM_2_DQ5: U_CHIP.L24
PSRAM_2_DQ6: U_CHIP.L25
PSRAM_2_DQ7: U_CHIP.L26
PSRAM_2_DQ8: U_CHIP.L27
PSRAM_2_DQ9: U_CHIP.L28
PSRAM_2_DQ10: U_CHIP.M24
PSRAM_2_DQ11: U_CHIP.M25
PSRAM_2_DQ12: U_CHIP.M26
PSRAM_2_DQ13: U_CHIP.M27
PSRAM_2_DQ14: U_CHIP.M28
PSRAM_2_DQ15: U_CHIP.N24
PSRAM_2_DQS0: U_CHIP.N25
PSRAM_2_DQS1: U_CHIP.N26
PSRAM_3_CE: U_CHIP.U27
PSRAM_3_DQ0: U_CHIP.P24
PSRAM_3_DQ1: U_CHIP.P25
PSRAM_3_DQ2: U_CHIP.P26
PSRAM_3_DQ3: U_CHIP.P27
PSRAM_3_DQ4: U_CHIP.P28
PSRAM_3_DQ5: U_CHIP.R24
PSRAM_3_DQ6: U_CHIP.R25
PSRAM_3_DQ7: U_CHIP.R26
PSRAM_3_DQ8: U_CHIP.R27
PSRAM_3_DQ9: U_CHIP.R28
PSRAM_3_DQ10: U_CHIP.T24
PSRAM_3_DQ11: U_CHIP.T25
PSRAM_3_DQ12: U_CHIP.T26
PSRAM_3_DQ13: U_CHIP.T27
PSRAM_3_DQ14: U_CHIP.T28
PSRAM_3_DQ15: U_CHIP.U24
PSRAM_3_DQS0: U_CHIP.U25
PSRAM_3_DQS1: U_CHIP.U26
PSRAM_4_CE: U_CHIP.AA27
PSRAM_4_DQ0: U_CHIP.V24
PSRAM_4_DQ1: U_CHIP.V25
PSRAM_4_DQ2: U_CHIP.V26
PSRAM_4_DQ3: U_CHIP.V27
PSRAM_4_DQ4: U_CHIP.V28
PSRAM_4_DQ5: U_CHIP.W24
PSRAM_4_DQ6: U_CHIP.W25
PSRAM_4_DQ7: U_CHIP.W26
PSRAM_4_DQ8: U_CHIP.W27
PSRAM_4_DQ9: U_CHIP.W28
PSRAM_4_DQ10: U_CHIP.Y24
PSRAM_4_DQ11: U_CHIP.Y25
PSRAM_4_DQ12: U_CHIP.Y26
PSRAM_4_DQ13: U_CHIP.Y27
PSRAM_4_DQ14: U_CHIP.Y28
PSRAM_4_DQ15: U_CHIP.AA24
PSRAM_4_DQS0: U_CHIP.AA25
PSRAM_4_DQS1: U_CHIP.AA26
PSRAM_5_CE: U_CHIP.G4
PSRAM_5_DQ0: U_CHIP.AB24
PSRAM_5_DQ1: U_CHIP.AB25
PSRAM_5_DQ2: U_CHIP.AB26
PSRAM_5_DQ3: U_CHIP.AB27
PSRAM_5_DQ4: U_CHIP.AB28
PSRAM_5_DQ5: U_CHIP.AC24
PSRAM_5_DQ6: U_CHIP.AC25
PSRAM_5_DQ7: U_CHIP.AC26
PSRAM_5_DQ8: U_CHIP.AC27
PSRAM_5_DQ9: U_CHIP.AC28
PSRAM_5_DQ10: U_CHIP.F1
PSRAM_5_DQ11: U_CHIP.F2
PSRAM_5_DQ12: U_CHIP.F3
PSRAM_5_DQ13: U_CHIP.F4
PSRAM_5_DQ14: U_CHIP.F5
PSRAM_5_DQ15: U_CHIP.G1
PSRAM_5_DQS0: U_CHIP.G2
PSRAM_5_DQS1: U_CHIP.G3
PSRAM_6_CE: U_CHIP.L4
PSRAM_6_DQ0: U_CHIP.H1
PSRAM_6_DQ1: U_CHIP.H2
PSRAM_6_DQ2: U_CHIP.H3
PSRAM_6_DQ3: U_CHIP.H4
PSRAM_6_DQ4: U_CHIP.H5
PSRAM_6_DQ5: U_CHIP.J1
PSRAM_6_DQ6: U_CHIP.J2
PSRAM_6_DQ7: U_CHIP.J3
PSRAM_6_DQ8: U_CHIP.J4
PSRAM_6_DQ9: U_CHIP.J5
PSRAM_6_DQ10: U_CHIP.K1
PSRAM_6_DQ11: U_CHIP.K2
PSRAM_6_DQ12: U_CHIP.K3
PSRAM_6_DQ13: U_CHIP.K4
PSRAM_6_DQ14: U_CHIP.K5
PSRAM_6_DQ15: U_CHIP.L1
PSRAM_6_DQS0: U_CHIP.L2
PSRAM_6_DQS1: U_CHIP.L3
PSRAM_7_CE: U_CHIP.R4
PSRAM_7_DQ0: U_CHIP.M1
PSRAM_7_DQ1: U_CHIP.M2
PSRAM_7_DQ2: U_CHIP.M3
PSRAM_7_DQ3: U_CHIP.M4
PSRAM_7_DQ4: U_CHIP.M5
PSRAM_7_DQ5: U_CHIP.N1
PSRAM_7_DQ6: U_CHIP.N2
PSRAM_7_DQ7: U_CHIP.N3
PSRAM_7_DQ8: U_CHIP.N4
PSRAM_7_DQ9: U_CHIP.N5
PSRAM_7_DQ10: U_CHIP.P1
PSRAM_7_DQ11: U_CHIP.P2
PSRAM_7_DQ12: U_CHIP.P3
PSRAM_7_DQ13: U_CHIP.P4
PSRAM_7_DQ14: U_CHIP.P5
PSRAM_7_DQ15: U_CHIP.R1
PSRAM_7_DQS0: U_CHIP.R2
PSRAM_7_DQS1: U_CHIP.R3
PSRAM_8_CE: U_CHIP.W4
PSRAM_8_DQ0: U_CHIP.T1
PSRAM_8_DQ1: U_CHIP.T2
PSRAM_8_DQ2: U_CHIP.T3
PSRAM_8_DQ3: U_CHIP.T4
PSRAM_8_DQ4: U_CHIP.T5
PSRAM_8_DQ5: U_CHIP.U1
PSRAM_8_DQ6: U_CHIP.U2
PSRAM_8_DQ7: U_CHIP.U3
PSRAM_8_DQ8: U_CHIP.U4
PSRAM_8_DQ9: U_CHIP.U5
PSRAM_8_DQ10: U_CHIP.V1
PSRAM_8_DQ11: U_CHIP.V2
PSRAM_8_DQ12: U_CHIP.V3
PSRAM_8_DQ13: U_CHIP.V4
PSRAM_8_DQ14: U_CHIP.V5
PSRAM_8_DQ15: U_CHIP.W1
PSRAM_8_DQS0: U_CHIP.W2
PSRAM_8_DQS1: U_CHIP.W3
PSRAM_9_CE: U_CHIP.AC4
PSRAM_9_DQ0: U_CHIP.Y1
PSRAM_9_DQ1: U_CHIP.Y2
PSRAM_9_DQ2: U_CHIP.Y3
PSRAM_9_DQ3: U_CHIP.Y4
PSRAM_9_DQ4: U_CHIP.Y5
PSRAM_9_DQ5: U_CHIP.AA1
PSRAM_9_DQ6: U_CHIP.AA2
PSRAM_9_DQ7: U_CHIP.AA3
PSRAM_9_DQ8: U_CHIP.AA4
PSRAM_9_DQ9: U_CHIP.AA5
PSRAM_9_DQ10: U_CHIP.AB1
PSRAM_9_DQ11: U_CHIP.AB2
PSRAM_9_DQ12: U_CHIP.AB3
PSRAM_9_DQ13: U_CHIP.AB4
PSRAM_9_DQ14: U_CHIP.AB5
PSRAM_9_DQ15: U_CHIP.AC1
PSRAM_9_DQS0: U_CHIP.AC2
PSRAM_9_DQS1: U_CHIP.AC3
PSRAM_10_CE: U_CHIP.D12
PSRAM_10_DQ0: U_CHIP.A9
PSRAM_10_DQ1: U_CHIP.B9
PSRAM_10_DQ2: U_CHIP.C9
PSRAM_10_DQ3: U_CHIP.D9
PSRAM_10_DQ4: U_CHIP.E9
PSRAM_10_DQ5: U_CHIP.A10
PSRAM_10_DQ6: U_CHIP.B10
PSRAM_10_DQ7: U_CHIP.C10
PSRAM_10_DQ8: U_CHIP.D10
PSRAM_10_DQ9: U_CHIP.E10
PSRAM_10_DQ10: U_CHIP.A11
PSRAM_10_DQ11: U_CHIP.B11
PSRAM_10_DQ12: U_CHIP.C11
PSRAM_10_DQ13: U_CHIP.D11
PSRAM_10_DQ14: U_CHIP.E11
PSRAM_10_DQ15: U_CHIP.A12
PSRAM_10_DQS0: U_CHIP.B12
PSRAM_10_DQS1: U_CHIP.C12
PSRAM_11_CE: U_CHIP.D16
PSRAM_11_DQ0: U_CHIP.A13
PSRAM_11_DQ1: U_CHIP.B13
PSRAM_11_DQ2: U_CHIP.C13
PSRAM_11_DQ3: U_CHIP.D13
PSRAM_11_DQ4: U_CHIP.E13
PSRAM_11_DQ5: U_CHIP.A14
PSRAM_11_DQ6: U_CHIP.B14
PSRAM_11_DQ7: U_CHIP.C14
PSRAM_11_DQ8: U_CHIP.D14
PSRAM_11_DQ9: U_CHIP.E14
PSRAM_11_DQ10: U_CHIP.A15
PSRAM_11_DQ11: U_CHIP.B15
PSRAM_11_DQ12: U_CHIP.C15
PSRAM_11_DQ13: U_CHIP.D15
PSRAM_11_DQ14: U_CHIP.E15
PSRAM_11_DQ15: U_CHIP.A16
PSRAM_11_DQS0: U_CHIP.B16
PSRAM_11_DQS1: U_CHIP.C16
PSRAM_12_CE: U_CHIP.D20
PSRAM_12_DQ0: U_CHIP.A17
PSRAM_12_DQ1: U_CHIP.B17
PSRAM_12_DQ2: U_CHIP.C17
PSRAM_12_DQ3: U_CHIP.D17
PSRAM_12_DQ4: U_CHIP.E17
PSRAM_12_DQ5: U_CHIP.A18
PSRAM_12_DQ6: U_CHIP.B18
PSRAM_12_DQ7: U_CHIP.C18
PSRAM_12_DQ8: U_CHIP.D18
PSRAM_12_DQ9: U_CHIP.E18
PSRAM_12_DQ10: U_CHIP.A19
PSRAM_12_DQ11: U_CHIP.B19
PSRAM_12_DQ12: U_CHIP.C19
PSRAM_12_DQ13: U_CHIP.D19
PSRAM_12_DQ14: U_CHIP.E19
PSRAM_12_DQ15: U_CHIP.A20
PSRAM_12_DQS0: U_CHIP.B20
PSRAM_12_DQS1: U_CHIP.C20
PSRAM_13_CE: U_CHIP.D24
PSRAM_13_DQ0: U_CHIP.A21
PSRAM_13_DQ1: U_CHIP.B21
PSRAM_13_DQ2: U_CHIP.C21
PSRAM_13_DQ3: U_CHIP.D21
PSRAM_13_DQ4: U_CHIP.E21
PSRAM_13_DQ5: U_CHIP.A22
PSRAM_13_DQ6: U_CHIP.B22
PSRAM_13_DQ7: U_CHIP.C22
PSRAM_13_DQ8: U_CHIP.D22
PSRAM_13_DQ9: U_CHIP.E22
PSRAM_13_DQ10: U_CHIP.A23
PSRAM_13_DQ11: U_CHIP.B23
PSRAM_13_DQ12: U_CHIP.C23
PSRAM_13_DQ13: U_CHIP.D23
PSRAM_13_DQ14: U_CHIP.E23
PSRAM_13_DQ15: U_CHIP.A24
PSRAM_13_DQS0: U_CHIP.B24
PSRAM_13_DQS1: U_CHIP.C24
PSRAM_14_CE: U_CHIP.D28
PSRAM_14_DQ0: U_CHIP.A25
PSRAM_14_DQ1: U_CHIP.B25
PSRAM_14_DQ2: U_CHIP.C25
PSRAM_14_DQ3: U_CHIP.D25
PSRAM_14_DQ4: U_CHIP.E25
PSRAM_14_DQ5: U_CHIP.A26
PSRAM_14_DQ6: U_CHIP.B26
PSRAM_14_DQ7: U_CHIP.C26
PSRAM_14_DQ8: U_CHIP.D26
PSRAM_14_DQ9: U_CHIP.E26
PSRAM_14_DQ10: U_CHIP.A27
PSRAM_14_DQ11: U_CHIP.B27
PSRAM_14_DQ12: U_CHIP.C27
PSRAM_14_DQ13: U_CHIP.D27
PSRAM_14_DQ14: U_CHIP.E27
PSRAM_14_DQ15: U_CHIP.A28
PSRAM_14_DQS0: U_CHIP.B28
PSRAM_14_DQS1: U_CHIP.C28
PSRAM_15_CE: U_CHIP.J27
PSRAM_15_DQ0: U_CHIP.F24
PSRAM_15_DQ1: U_CHIP.F25
PSRAM_15_DQ2: U_CHIP.F26
PSRAM_15_DQ3: U_CHIP.F27
PSRAM_15_DQ4: U_CHIP.F28
PSRAM_15_DQ5: U_CHIP.G24
PSRAM_15_DQ6: U_CHIP.G25
PSRAM_15_DQ7: U_CHIP.G26
PSRAM_15_DQ8: U_CHIP.G27
PSRAM_15_DQ9: U_CHIP.G28
PSRAM_15_DQ10: U_CHIP.H24
PSRAM_15_DQ11: U_CHIP.H25
PSRAM_15_DQ12: U_CHIP.H26
PSRAM_15_DQ13: U_CHIP.H27
PSRAM_15_DQ14: U_CHIP.H28
PSRAM_15_DQ15: U_CHIP.J24
PSRAM_15_DQS0: U_CHIP.J25
PSRAM_15_DQS1: U_CHIP.J26
PSRAM_CLK0: U_CHIP.F6; also elsewhere on the board
PSRAM_CLK1: U_CHIP.F7; also elsewhere on the board
PSRAM_CLK2: U_CHIP.F8; also elsewhere on the board
PSRAM_CLK3: U_CHIP.F9; also elsewhere on the board
PSRAM_CLK4: U_CHIP.F10; also elsewhere on the board
PSRAM_CLK5: U_CHIP.F11; also elsewhere on the board
PSRAM_CLK6: U_CHIP.F12; also elsewhere on the board
PSRAM_CLK7: U_CHIP.F13; also elsewhere on the board
PSRAM_CLK8: U_CHIP.F14; also elsewhere on the board
PSRAM_CLK9: U_CHIP.F15; also elsewhere on the board
PSRAM_CLK10: U_CHIP.F16; also elsewhere on the board
PSRAM_CLK11: U_CHIP.F17; also elsewhere on the board
PSRAM_CLK12: U_CHIP.F18; also elsewhere on the board
PSRAM_CLK13: U_CHIP.F19; also elsewhere on the board
PSRAM_CLK14: U_CHIP.F20; also elsewhere on the board
PSRAM_CLK15: U_CHIP.F21; also elsewhere on the board
REFCLK_CHIP_N: U_CHIP.AG9
REFCLK_CHIP_P: U_CHIP.AH21
REFCLK_CLK_N: J_EDGE.A61
REFCLK_CLK_P: J_EDGE.A60
STRAP_MODE0: J_EDGE.A62
STRAP_MODE1: J_EDGE.A63
VDD_CORE: U_CHIP.AA8, U_CHIP.AA10, U_CHIP.AA12, U_CHIP.AA14, U_CHIP.AA18, U_CHIP.AA20, U_CHIP.AA22, U_CHIP.AB7, U_CHIP.AB9, U_CHIP.AB11, U_CHIP.AB13, U_CHIP.AB15, U_CHIP.AB17, U_CHIP.AB19, U_CHIP.AB21, U_CHIP.AB23, U_CHIP.AC6, U_CHIP.AC8, U_CHIP.AC10, U_CHIP.AC12, U_CHIP.AC14, U_CHIP.AC16, U_CHIP.AC18, U_CHIP.AC20, U_CHIP.AC22, U_CHIP.AD1, U_CHIP.AD3, U_CHIP.AD5, U_CHIP.AD7, U_CHIP.AD9, U_CHIP.AD11, U_CHIP.AD13, U_CHIP.AD15, U_CHIP.AD17, U_CHIP.AD19, U_CHIP.AD21, U_CHIP.AD23, U_CHIP.AD25, U_CHIP.AD27, U_CHIP.AE2, U_CHIP.AE4, U_CHIP.AE6, U_CHIP.AE8, U_CHIP.AE10, U_CHIP.AE12, U_CHIP.AE14, U_CHIP.AE16, U_CHIP.AE18, U_CHIP.AE20, U_CHIP.AE22, U_CHIP.AE24, U_CHIP.AE26, U_CHIP.AE28, U_CHIP.AF1, U_CHIP.AF3, U_CHIP.AF5, U_CHIP.AF7, U_CHIP.AF9, U_CHIP.AF11, U_CHIP.AF13, U_CHIP.AF15, U_CHIP.AF17, U_CHIP.AF19, U_CHIP.AF21, U_CHIP.AF23, U_CHIP.AF25, U_CHIP.AF27, U_CHIP.AG2, U_CHIP.AG14, U_CHIP.AG16, U_CHIP.AG18, U_CHIP.AG20, U_CHIP.AG28, U_CHIP.AH1, U_CHIP.F23, U_CHIP.G6, U_CHIP.G8, U_CHIP.G10, U_CHIP.G14, U_CHIP.G16, U_CHIP.G18, U_CHIP.G20, U_CHIP.H7, U_CHIP.H9, U_CHIP.H11, U_CHIP.H15, U_CHIP.H17, U_CHIP.H19, U_CHIP.H21, U_CHIP.J6, U_CHIP.J8, U_CHIP.J10, U_CHIP.J12, U_CHIP.J16, U_CHIP.J18, U_CHIP.J20, U_CHIP.J22, U_CHIP.K7, U_CHIP.K9, U_CHIP.K11, U_CHIP.K13, U_CHIP.K17, U_CHIP.K19, U_CHIP.K21, U_CHIP.K23, U_CHIP.L8, U_CHIP.L10, U_CHIP.L12, U_CHIP.L14, U_CHIP.L18, U_CHIP.L20, U_CHIP.L22, U_CHIP.M9, U_CHIP.M11, U_CHIP.M13, U_CHIP.M15, U_CHIP.M19, U_CHIP.M21, U_CHIP.M23, U_CHIP.N6, U_CHIP.N10, U_CHIP.N12, U_CHIP.N14, U_CHIP.N16, U_CHIP.N20, U_CHIP.N22, U_CHIP.P7, U_CHIP.P11, U_CHIP.P13, U_CHIP.P15, U_CHIP.P17, U_CHIP.P21, U_CHIP.P23, U_CHIP.R6, U_CHIP.R8, U_CHIP.R12, U_CHIP.R14, U_CHIP.R16, U_CHIP.R18, U_CHIP.R22, U_CHIP.T7, U_CHIP.T9, U_CHIP.T13, U_CHIP.T15, U_CHIP.T17, U_CHIP.T19, U_CHIP.T23, U_CHIP.U6, U_CHIP.U8, U_CHIP.U10, U_CHIP.U14, U_CHIP.U16, U_CHIP.U18, U_CHIP.U20, U_CHIP.V7, U_CHIP.V9, U_CHIP.V11, U_CHIP.V15, U_CHIP.V17, U_CHIP.V19, U_CHIP.V21, U_CHIP.W6, U_CHIP.W8, U_CHIP.W10, U_CHIP.W12, U_CHIP.W16, U_CHIP.W18, U_CHIP.W20, U_CHIP.W22, U_CHIP.Y7, U_CHIP.Y9, U_CHIP.Y11, U_CHIP.Y13, U_CHIP.Y17, U_CHIP.Y19, U_CHIP.Y21, U_CHIP.Y23; also elsewhere on the board
VDD_IO_1V8: U_CHIP.G12, U_CHIP.G22, U_CHIP.H13, U_CHIP.H23, U_CHIP.J14, U_CHIP.K15, U_CHIP.L6, U_CHIP.L16, U_CHIP.M7, U_CHIP.M17, U_CHIP.N8, U_CHIP.N18, U_CHIP.P9, U_CHIP.P19, U_CHIP.R10, U_CHIP.R20, U_CHIP.T11, U_CHIP.T21, U_CHIP.U12, U_CHIP.U22, U_CHIP.V13, U_CHIP.V23, U_CHIP.W14, U_CHIP.Y15; also elsewhere on the board
VDD_PLL_0V9: U_CHIP.AA6, U_CHIP.AA16; also elsewhere on the board
VRM_EN: J_EDGE.B52; also elsewhere on the board
